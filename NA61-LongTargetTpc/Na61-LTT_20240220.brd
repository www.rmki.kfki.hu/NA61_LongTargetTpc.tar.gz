# EAGLE board Na61-LTT_20240220 (EAGLE 9.6.2), part 2 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$1196 (continued)
  Bottom 0.8: 42.8,33.1 42.8,34.9
S$1197
  Bottom 0.8: 44.8,33.1 44.8,34.9
S$1198
  Bottom 0.8: 39.8,30.9 39.8,29.1
S$1199
  Bottom 0.8: 41.8,30.9 41.8,29.1
S$1200
  Bottom 0.8: 40.8,33.1 40.8,34.9
S$1201
  Bottom 0.8: 38.8,33.1 38.8,34.9
S$1202
  Bottom 0.8: 37.8,30.9 37.8,29.1
S$1203
  Bottom 0.8: 35.8,30.9 35.8,29.1
S$1204
  Bottom 0.8: 36.8,33.1 36.8,34.9
S$1205
  Bottom 0.8: 34.8,33.1 34.8,34.9
S$1206
  Bottom 0.8: 33.8,30.9 33.8,29.1
S$1207
  Bottom 0.8: 31.8,30.9 31.8,29.1
S$1208
  Bottom 0.8: 32.8,33.1 32.8,34.9
S$1209
  Bottom 0.8: 51.8,30.9 51.8,29.1
S$1210
  Bottom 0.8: 53.8,30.9 53.8,29.1
S$1211
  Bottom 0.8: 50.8,33.1 50.8,34.9
S$1212
  Bottom 0.8: 52.8,33.1 52.8,34.9
S$1213
  Bottom 0.8: 47.8,30.9 47.8,29.1
S$1214
  Bottom 0.8: 49.8,30.9 49.8,29.1
S$1215
  Bottom 0.8: 46.8,33.1 46.8,34.9
S$1216
  Bottom 0.8: 48.8,33.1 48.8,34.9
S$1217  (via drill 0.2)
  other vias: -50.8,40
S$1218  (via drill 0.2)
  other vias: -49.2,40
S$1219  (via drill 0.2)
  other vias: -47.6,40
S$1220  (via drill 0.2)
  other vias: -46,40
S$1221  (via drill 0.2)
  other vias: -44.4,40
S$1222  (via drill 0.2)
  other vias: -42.8,40
S$1223  (via drill 0.2)
  other vias: -41.2,40
S$1224  (via drill 0.2)
  other vias: -39.6,40
S$1225  (via drill 0.2)
  other vias: -38,40
S$1226  (via drill 0.2)
  other vias: -36.4,40
S$1227  (via drill 0.2)
  other vias: -34.8,40
S$1228  (via drill 0.2)
  other vias: -50,36
S$1229  (via drill 0.2)
  other vias: -48.4,36
S$1230  (via drill 0.2)
  other vias: -46.8,36
S$1231  (via drill 0.2)
  other vias: -45.2,36
S$1232  (via drill 0.2)
  other vias: -43.6,36
S$1233  (via drill 0.2)
  other vias: -42,36
S$1234  (via drill 0.2)
  other vias: -40.4,36
S$1235  (via drill 0.2)
  other vias: -38.8,36
S$1236  (via drill 0.2)
  other vias: -37.2,36
S$1237  (via drill 0.2)
  other vias: -35.6,36
S$1238  (via drill 0.2)
  other vias: -34,32
S$1239  (via drill 0.2)
  other vias: -32.4,32
S$1240  (via drill 0.2)
  other vias: -30.8,32
S$1241  (via drill 0.2)
  other vias: -29.2,32
S$1242  (via drill 0.2)
  other vias: -27.6,32
S$1243  (via drill 0.2)
  other vias: -33.2,36
S$1244  (via drill 0.2)
  other vias: -31.6,36
S$1245  (via drill 0.2)
  other vias: -30,36
S$1246  (via drill 0.2)
  other vias: -28.4,36
S$1247  (via drill 0.2)
  other vias: -26.8,36
S$1248  (via drill 0.2)
  other vias: -26,32
S$1249  (via drill 0.2)
  other vias: -0.4,40
S$1250  (via drill 0.2)
  other vias: -2,40
S$1251  (via drill 0.2)
  other vias: -3.6,40
S$1252  (via drill 0.2)
  other vias: -5.2,40
S$1253  (via drill 0.2)
  other vias: -6.8,40
S$1254  (via drill 0.2)
  other vias: -8.4,40
S$1255  (via drill 0.2)
  other vias: -10,40
S$1256  (via drill 0.2)
  other vias: -11.6,40
S$1257  (via drill 0.2)
  other vias: -13.2,40
S$1258  (via drill 0.2)
  other vias: -14.8,40
S$1259  (via drill 0.2)
  other vias: -16.4,40
S$1260  (via drill 0.2)
  other vias: -1.2,36
S$1261  (via drill 0.2)
  other vias: -2.8,36
S$1262  (via drill 0.2)
  other vias: -4.4,36
S$1263  (via drill 0.2)
  other vias: -6,36
S$1264  (via drill 0.2)
  other vias: -7.6,36
S$1265  (via drill 0.2)
  other vias: -9.2,36
S$1266  (via drill 0.2)
  other vias: -10.8,36
S$1267  (via drill 0.2)
  other vias: -12.4,36
S$1268  (via drill 0.2)
  other vias: -14,36
S$1269  (via drill 0.2)
  other vias: -15.6,36
S$1270  (via drill 0.2)
  other vias: -17.2,32
S$1271  (via drill 0.2)
  other vias: -18.8,32
S$1272  (via drill 0.2)
  other vias: -20.4,32
S$1273  (via drill 0.2)
  other vias: -22,32
S$1274  (via drill 0.2)
  other vias: -23.6,32
S$1275  (via drill 0.2)
  other vias: -18,36
S$1276  (via drill 0.2)
  other vias: -19.6,36
S$1277  (via drill 0.2)
  other vias: -21.2,36
S$1278  (via drill 0.2)
  other vias: -22.8,36
S$1279  (via drill 0.2)
  other vias: -24.4,36
S$1280  (via drill 0.2)
  other vias: -25.2,32
S$1281  (via drill 0.2)
  other vias: 0.4,36
S$1282  (via drill 0.2)
  other vias: 2,36
S$1283  (via drill 0.2)
  other vias: 3.6,36
S$1284  (via drill 0.2)
  other vias: 5.2,36
S$1285  (via drill 0.2)
  other vias: 6.8,36
S$1286  (via drill 0.2)
  other vias: 8.4,36
S$1287  (via drill 0.2)
  other vias: 10,36
S$1288  (via drill 0.2)
  other vias: 11.6,36
S$1289  (via drill 0.2)
  other vias: 13.2,36
S$1290  (via drill 0.2)
  other vias: 14.8,36
S$1291  (via drill 0.2)
  other vias: 16.4,32
S$1292  (via drill 0.2)
  other vias: 1.2,32
S$1293  (via drill 0.2)
  other vias: 2.8,32
S$1294  (via drill 0.2)
  other vias: 4.4,32
S$1295  (via drill 0.2)
  other vias: 6,32
S$1296  (via drill 0.2)
  other vias: 7.6,32
S$1297  (via drill 0.2)
  other vias: 9.2,32
S$1298  (via drill 0.2)
  other vias: 10.8,32
S$1299  (via drill 0.2)
  other vias: 12.4,32
S$1300  (via drill 0.2)
  other vias: 14,32
S$1301  (via drill 0.2)
  other vias: 15.6,32
S$1302  (via drill 0.2)
  other vias: 17.2,36
S$1303  (via drill 0.2)
  other vias: 18.8,36
S$1304  (via drill 0.2)
  other vias: 20.4,36
S$1305  (via drill 0.2)
  other vias: 18,40
S$1306  (via drill 0.2)
  other vias: 19.6,40
S$1307  (via drill 0.2)
  other vias: 21.2,40
S$1308  (via drill 0.2)
  other vias: 22,36
S$1309  (via drill 0.2)
  other vias: 22.8,40
S$1310  (via drill 0.2)
  other vias: 23.6,36
S$1311  (via drill 0.2)
  other vias: 24.4,40
S$1312  (via drill 0.2)
  other vias: 25.2,36
S$1313  (via drill 0.2)
  other vias: 50.8,36
S$1314  (via drill 0.2)
  other vias: 49.2,36
S$1315  (via drill 0.2)
  other vias: 47.6,36
S$1316  (via drill 0.2)
  other vias: 46,36
S$1317  (via drill 0.2)
  other vias: 44.4,36
S$1318  (via drill 0.2)
  other vias: 42.8,36
S$1319  (via drill 0.2)
  other vias: 41.2,36
S$1320  (via drill 0.2)
  other vias: 39.6,36
S$1321  (via drill 0.2)
  other vias: 38,36
S$1322  (via drill 0.2)
  other vias: 36.4,36
S$1323  (via drill 0.2)
  other vias: 34.8,32
S$1324  (via drill 0.2)
  other vias: 50,32
S$1325  (via drill 0.2)
  other vias: 48.4,32
S$1326  (via drill 0.2)
  other vias: 46.8,32
S$1327  (via drill 0.2)
  other vias: 45.2,32
S$1328  (via drill 0.2)
  other vias: 43.6,32
S$1329  (via drill 0.2)
  other vias: 42,32
S$1330  (via drill 0.2)
  other vias: 40.4,32
S$1331  (via drill 0.2)
  other vias: 38.8,32
S$1332  (via drill 0.2)
  other vias: 37.2,32
S$1333  (via drill 0.2)
  other vias: 35.6,32
S$1334  (via drill 0.2)
  other vias: 34,36
S$1335  (via drill 0.2)
  other vias: 32.4,36
S$1336  (via drill 0.2)
  other vias: 30.8,36
S$1337  (via drill 0.2)
  other vias: 33.2,40
S$1338  (via drill 0.2)
  other vias: 31.6,40
S$1339  (via drill 0.2)
  other vias: 30,40
S$1340  (via drill 0.2)
  other vias: 29.2,36
S$1341  (via drill 0.2)
  other vias: 28.4,40
S$1342  (via drill 0.2)
  other vias: 27.6,36
S$1343  (via drill 0.2)
  other vias: 26.8,40
S$1344  (via drill 0.2)
  other vias: 26,36
S$1345
  Bottom 0.152: -52.8,41 -51.8,40
S$1346
  Bottom 0.152: -51.8,40 -50.8,40
S$1347
  Bottom 0.152: -50.8,41 -50.2,41
S$1348
  Bottom 0.152: -50.2,41 -49.2,40
S$1349
  Bottom 0.152: -48.8,41 -48.6,41
S$1350
  Bottom 0.152: -48.6,41 -47.6,40
S$1351
  Bottom 0.152: -46.8,41 -46,40.2
S$1352
  Bottom 0.152: -46,40.2 -46,40
S$1353
  Bottom 0.152: -44.8,41 -44.4,40.6
S$1354
  Bottom 0.152: -44.4,40.6 -44.4,40
S$1355
  Bottom 0.152: -42.8,41 -42.8,40
S$1356
  Bottom 0.152: -40.8,41 -41.2,40.6
S$1357
  Bottom 0.152: -41.2,40.6 -41.2,40
S$1358
  Bottom 0.152: -38.8,41 -39.6,40.2
S$1359
  Bottom 0.152: -39.6,40.2 -39.6,40
S$1360
  Bottom 0.152: -36.8,41 -37,41
S$1361
  Bottom 0.152: -37,41 -38,40
S$1362
  Bottom 0.152: -34.8,41 -35.4,41
S$1363
  Bottom 0.152: -35.4,41 -36.4,40
S$1364
  Bottom 0.152: -32.8,41 -33.8,40
S$1365
  Bottom 0.152: -33.8,40 -34.8,40
S$1366
  Bottom 0.152: -51.8,37 -50.8,36
S$1367
  Bottom 0.152: -50.8,36 -50,36
S$1368
  Bottom 0.152: -49.8,37 -48.8,36
S$1369
  Bottom 0.152: -48.8,36 -48.4,36
S$1370
  Bottom 0.152: -47.8,37 -46.8,36
S$1371
  Bottom 0.152: -45.8,37 -45.2,36.4
S$1372
  Bottom 0.152: -45.2,36.4 -45.2,36
S$1373
  Bottom 0.152: -43.8,37 -43.6,36.8
S$1374
  Bottom 0.152: -43.6,36.8 -43.6,36
S$1375
  Bottom 0.152: -41.8,37 -42,36.8
S$1376
  Bottom 0.152: -42,36.8 -42,36
S$1377
  Bottom 0.152: -39.8,37 -40.4,36.4
S$1378
  Bottom 0.152: -40.4,36.4 -40.4,36
S$1379
  Bottom 0.152: -37.8,37 -38.8,36
S$1380
  Bottom 0.152: -35.8,37 -36.8,36
S$1381
  Bottom 0.152: -36.8,36 -37.2,36
S$1382
  Bottom 0.152: -33.8,37 -34.8,36
S$1383
  Bottom 0.152: -34.8,36 -35.6,36
S$1384
  Bottom 0.152: -36.6,31 -35.6,32
S$1385
  Bottom 0.152: -35.6,32 -34,32
S$1386
  Bottom 0.152: -34.6,31 -33.8,31
S$1387
  Bottom 0.152: -33.8,31 -32.8,32
S$1388
  Bottom 0.152: -32.8,32 -32.4,32
S$1389
  Bottom 0.152: -32.6,31 -31.8,31
S$1390
  Bottom 0.152: -31.8,31 -30.8,32
S$1391
  Bottom 0.152: -30.6,31 -30.2,31
S$1392
  Bottom 0.152: -30.2,31 -29.2,32
S$1393
  Bottom 0.152: -28.6,31 -27.6,32
S$1394
  Bottom 0.152: -26.6,31 -26,31.6
S$1395
  Bottom 0.152: -26,31.6 -26,32
S$1396
  Bottom 0.152: -35.6,35 -35,35
S$1397
  Bottom 0.152: -35,35 -34,36
S$1398
  Bottom 0.152: -34,36 -33.2,36
S$1399
  Bottom 0.152: -33.6,35 -33,35
S$1400
  Bottom 0.152: -33,35 -32,36
S$1401
  Bottom 0.152: -32,36 -31.6,36
S$1402
  Bottom 0.152: -31.6,35 -31,35
S$1403
  Bottom 0.152: -31,35 -30,36
S$1404
  Bottom 0.152: -29.6,35 -29.4,35
S$1405
  Bottom 0.152: -29.4,35 -28.4,36
S$1406
  Bottom 0.152: -27.6,35 -26.8,35.8
S$1407
  Bottom 0.152: -26.8,35.8 -26.8,36
S$1408
  Bottom 0.152: 1.6,41 0.6,40
S$1409
  Bottom 0.152: 0.6,40 -0.4,40
S$1410
  Bottom 0.152: -0.4,41 -1,41
S$1411
  Bottom 0.152: -1,41 -2,40
S$1412
  Bottom 0.152: -2.4,41 -2.6,41
S$1413
  Bottom 0.152: -2.6,41 -3.6,40
S$1414
  Bottom 0.152: -4.4,41 -5.2,40.2
S$1415
  Bottom 0.152: -5.2,40.2 -5.2,40
S$1416
  Bottom 0.152: -6.4,41 -6.8,40.6
S$1417
  Bottom 0.152: -6.8,40.6 -6.8,40
S$1418
  Bottom 0.152: -8.4,41 -8.4,40
S$1419
  Bottom 0.152: -10.4,41 -10,40.6
S$1420
  Bottom 0.152: -10,40.6 -10,40
S$1421
  Bottom 0.152: -12.4,41 -11.6,40.2
S$1422
  Bottom 0.152: -11.6,40.2 -11.6,40
S$1423
  Bottom 0.152: -14.4,41 -14.2,41
S$1424
  Bottom 0.152: -14.2,41 -13.2,40
S$1425
  Bottom 0.152: -16.4,41 -15.8,41
S$1426
  Bottom 0.152: -15.8,41 -14.8,40
S$1427
  Bottom 0.152: -18.4,41 -17.4,40
S$1428
  Bottom 0.152: -17.4,40 -16.4,40
S$1429
  Bottom 0.152: 0.6,37 -0.4,36
S$1430
  Bottom 0.152: -0.4,36 -1.2,36
S$1431
  Bottom 0.152: -1.4,37 -2.4,36
S$1432
  Bottom 0.152: -2.4,36 -2.8,36
S$1433
  Bottom 0.152: -3.4,37 -4.4,36
S$1434
  Bottom 0.152: -5.4,37 -6,36.4
S$1435
  Bottom 0.152: -6,36.4 -6,36
S$1436
  Bottom 0.152: -7.4,37 -7.6,36.8
S$1437
  Bottom 0.152: -7.6,36.8 -7.6,36
S$1438
  Bottom 0.152: -9.4,37 -9.2,36.8
S$1439
  Bottom 0.152: -9.2,36.8 -9.2,36
S$1440
  Bottom 0.152: -11.4,37 -10.8,36.4
S$1441
  Bottom 0.152: -10.8,36.4 -10.8,36
S$1442
  Bottom 0.152: -13.4,37 -12.4,36
S$1443
  Bottom 0.152: -15.4,37 -14.4,36
S$1444
  Bottom 0.152: -14.4,36 -14,36
S$1445
  Bottom 0.152: -17.4,37 -16.4,36
S$1446
  Bottom 0.152: -16.4,36 -15.6,36
S$1447
  Bottom 0.152: -14.6,31 -15.6,32
S$1448
  Bottom 0.152: -15.6,32 -17.2,32
S$1449
  Bottom 0.152: -16.6,31 -17.4,31
S$1450
  Bottom 0.152: -17.4,31 -18.4,32
S$1451
  Bottom 0.152: -18.4,32 -18.8,32
S$1452
  Bottom 0.152: -18.6,31 -19.4,31
S$1453
  Bottom 0.152: -19.4,31 -20.4,32
S$1454
  Bottom 0.152: -20.6,31 -21,31
S$1455
  Bottom 0.152: -21,31 -22,32
S$1456
  Bottom 0.152: -22.6,31 -23.6,32
S$1457
  Bottom 0.152: -24.6,31 -25.2,31.6
S$1458
  Bottom 0.152: -25.2,31.6 -25.2,32
S$1459
  Bottom 0.152: -15.6,35 -16.2,35
S$1460
  Bottom 0.152: -16.2,35 -17.2,36
S$1461
  Bottom 0.152: -17.2,36 -18,36
S$1462
  Bottom 0.152: -17.6,35 -18.2,35
S$1463
  Bottom 0.152: -18.2,35 -19.2,36
S$1464
  Bottom 0.152: -19.2,36 -19.6,36
S$1465
  Bottom 0.152: -19.6,35 -20.2,35
S$1466
  Bottom 0.152: -20.2,35 -21.2,36
S$1467
  Bottom 0.152: -21.6,35 -21.8,35
S$1468
  Bottom 0.152: -21.8,35 -22.8,36
S$1469
  Bottom 0.152: -23.6,35 -24.4,35.8
S$1470
  Bottom 0.152: -24.4,35.8 -24.4,36
S$1471
  Bottom 0.152: 0.4,35 1,35
S$1472
  Bottom 0.152: 1,35 2,36
S$1473
  Bottom 0.152: 2.4,35 2.6,35
S$1474
  Bottom 0.152: 2.6,35 3.6,36
S$1475
  Bottom 0.152: 4.4,35 5.2,35.8
S$1476
  Bottom 0.152: 5.2,35.8 5.2,36
S$1477
  Bottom 0.152: 6.4,35 6.8,35.4
S$1478
  Bottom 0.152: 6.8,35.4 6.8,36
S$1479
  Bottom 0.152: 8.4,35 8.4,36
S$1480
  Bottom 0.152: -1.6,35 -0.6,35
S$1481
  Bottom 0.152: -0.6,35 0.4,36
S$1482
  Bottom 0.152: -0.6,31 0.4,32
S$1483
  Bottom 0.152: 0.4,32 1.2,32
S$1484
  Bottom 0.152: 1.4,31 1.8,31
S$1485
  Bottom 0.152: 1.8,31 2.8,32
S$1486
  Bottom 0.152: 3.4,31 4.4,32
S$1487
  Bottom 0.152: 5.4,31 6,31.6
S$1488
  Bottom 0.152: 6,31.6 6,32
S$1489
  Bottom 0.152: 7.4,31 7.6,31.2
S$1490
  Bottom 0.152: 7.6,31.2 7.6,32
S$1491
  Bottom 0.152: 9.4,31 9.2,31.2
S$1492
  Bottom 0.152: 9.2,31.2 9.2,32
S$1493
  Bottom 0.152: 11.4,31 10.8,31.6
S$1494
  Bottom 0.152: 10.8,31.6 10.8,32
S$1495
  Bottom 0.152: 13.4,31 12.4,32
S$1496
  Bottom 0.152: 15.4,31 15,31
S$1497
  Bottom 0.152: 15,31 14,32
S$1498
  Bottom 0.152: 17.4,31 16.6,31
S$1499
  Bottom 0.152: 16.6,31 15.6,32
S$1500
  Bottom 0.152: 10.4,35 10,35.4
S$1501
  Bottom 0.152: 10,35.4 10,36
S$1502
  Bottom 0.152: 12.4,35 11.6,35.8
S$1503
  Bottom 0.152: 11.6,35.8 11.6,36
S$1504
  Bottom 0.152: 14.4,35 14.2,35
S$1505
  Bottom 0.152: 14.2,35 13.2,36
S$1506
  Bottom 0.152: 16.4,35 15.8,35
S$1507
  Bottom 0.152: 15.8,35 14.8,36
S$1508
  Bottom 0.152: 18.4,33 17.4,32
S$1509
  Bottom 0.152: 17.4,32 16.4,32
S$1510
  Bottom 0.152: 16.6,37 17.2,37
S$1511
  Bottom 0.152: 17.2,37 18.2,36
S$1512
  Bottom 0.152: 18.2,36 18.8,36
S$1513
  Bottom 0.152: 18.6,37 19.6,36
S$1514
  Bottom 0.152: 19.6,36 20.4,36
S$1515
  Bottom 0.152: 20.6,37 21.6,36
S$1516
  Bottom 0.152: 21.6,36 22,36
S$1517
  Bottom 0.152: 22.6,37 23.6,36
S$1518
  Bottom 0.152: 24.6,37 25.2,36.4
S$1519
  Bottom 0.152: 25.2,36.4 25.2,36
S$1520
  Bottom 0.152: 15.6,41 16.6,40
S$1521
  Bottom 0.152: 16.6,40 18,40
S$1522
  Bottom 0.152: 17.6,41 18,41
S$1523
  Bottom 0.152: 18,41 19,40
S$1524
  Bottom 0.152: 19,40 19.6,40
S$1525
  Bottom 0.152: 19.6,41 20.2,41
S$1526
  Bottom 0.152: 20.2,41 21.2,40
S$1527
  Bottom 0.152: 21.6,41 21.8,41
S$1528
  Bottom 0.152: 21.8,41 22.8,40
S$1529
  Bottom 0.152: 23.6,41 24.4,40.2
S$1530
  Bottom 0.152: 24.4,40.2 24.4,40
S$1531
  Bottom 0.152: 17.2,36 16,36
S$1532
  Bottom 0.152: 16,36 15,37
S$1533
  Bottom 0.152: 15,37 14.6,37
S$1534
  Bottom 0.152: 50.8,35 50.2,35
S$1535
  Bottom 0.152: 50.2,35 49.2,36
S$1536
  Bottom 0.152: 48.8,35 48.6,35
S$1537
  Bottom 0.152: 48.6,35 47.6,36
S$1538
  Bottom 0.152: 46.8,35 46,35.8
S$1539
  Bottom 0.152: 46,35.8 46,36
S$1540
  Bottom 0.152: 44.8,35 44.4,35.4
S$1541
  Bottom 0.152: 44.4,35.4 44.4,36
S$1542
  Bottom 0.152: 42.8,35 42.8,36
S$1543
  Bottom 0.152: 52.8,35 51.8,35
S$1544
  Bottom 0.152: 51.8,35 50.8,36
S$1545
  Bottom 0.152: 51.8,31 50.8,32
S$1546
  Bottom 0.152: 50.8,32 50,32
S$1547
  Bottom 0.152: 49.8,31 49.4,31
S$1548
  Bottom 0.152: 49.4,31 48.4,32
S$1549
  Bottom 0.152: 47.8,31 46.8,32
S$1550
  Bottom 0.152: 45.8,31 45.2,31.6
S$1551
  Bottom 0.152: 45.2,31.6 45.2,32
S$1552
  Bottom 0.152: 43.8,31 43.6,31.2
S$1553
  Bottom 0.152: 43.6,31.2 43.6,32
S$1554
  Bottom 0.152: 41.8,31 42,31.2
S$1555
  Bottom 0.152: 42,31.2 42,32
S$1556
  Bottom 0.152: 39.8,31 40.4,31.6
S$1557
  Bottom 0.152: 40.4,31.6 40.4,32
S$1558
  Bottom 0.152: 37.8,31 38.8,32
S$1559
  Bottom 0.152: 35.8,31 36.2,31
S$1560
  Bottom 0.152: 36.2,31 37.2,32
S$1561
  Bottom 0.152: 33.8,31 34.6,31
S$1562
  Bottom 0.152: 34.6,31 35.6,32
S$1563
  Bottom 0.152: 40.8,35 41.2,35.4
S$1564
  Bottom 0.152: 41.2,35.4 41.2,36
S$1565
  Bottom 0.152: 38.8,35 39.6,35.8
S$1566
  Bottom 0.152: 39.6,35.8 39.6,36
S$1567
  Bottom 0.152: 36.8,35 37,35
S$1568
  Bottom 0.152: 37,35 38,36
S$1569
  Bottom 0.152: 34.8,35 35.4,35
S$1570
  Bottom 0.152: 35.4,35 36.4,36
S$1571
  Bottom 0.152: 32.8,33 33.8,32
S$1572
  Bottom 0.152: 33.8,32 34.8,32
S$1573
  Bottom 0.152: 34.6,37 34,37
S$1574
  Bottom 0.152: 34,37 33,36
S$1575
  Bottom 0.152: 33,36 32.4,36
S$1576
  Bottom 0.152: 32.6,37 31.6,36
S$1577
  Bottom 0.152: 31.6,36 30.8,36
S$1578
  Bottom 0.152: 30.6,37 29.6,36
S$1579
  Bottom 0.152: 29.6,36 29.2,36
S$1580
  Bottom 0.152: 28.6,37 27.6,36
S$1581
  Bottom 0.152: 26.6,37 26,36.4
S$1582
  Bottom 0.152: 26,36.4 26,36
S$1583
  Bottom 0.152: 35.6,41 34.6,40
S$1584
  Bottom 0.152: 34.6,40 33.2,40
S$1585
  Bottom 0.152: 33.6,41 33.2,41
S$1586
  Bottom 0.152: 33.2,41 32.2,40
S$1587
  Bottom 0.152: 32.2,40 31.6,40
S$1588
  Bottom 0.152: 31.6,41 31,41
S$1589
  Bottom 0.152: 31,41 30,40
S$1590
  Bottom 0.152: 29.6,41 29.4,41
S$1591
  Bottom 0.152: 29.4,41 28.4,40
S$1592
  Bottom 0.152: 27.6,41 26.8,40.2
S$1593
  Bottom 0.152: 26.8,40.2 26.8,40
S$1594
  Bottom 0.152: 34,36 35.2,36
S$1595
  Bottom 0.152: 35.2,36 36.2,37
S$1596
  Bottom 0.152: 36.2,37 36.6,37
S$1597  (2 unrouted)
  Top 0.813: 65,40.5 65,31.5
  Top 1.8: 66,37.5 64,37.5 | 66,40.5 65,40.5 64,40.5 | 66,34.5 64,34.5 | 66,31.5 65,31.5 64,31.5
S$1598
  Top 1.778: -104.08,32.83 -104.08,34.35
S$1599
  Top 1.778: -104.08,37.65 -104.08,39.17
S$1600
  Top 1.778: -99,32.83 -99,34.35
S$1601
  Top 1.778: -99,37.65 -99,39.17
S$1602
  Top 1.778: -93.92,32.83 -93.92,34.35
S$1603
  Top 1.778: -93.92,37.65 -93.92,39.17
S$1604
  Top 1.778: 93.92,32.83 93.92,34.35
S$1605
  Top 1.778: 93.92,37.65 93.92,39.17
S$1606
  Top 1.778: 99,32.83 99,34.35
S$1607
  Top 1.778: 99,37.65 99,39.17
S$1608
  Top 1.778: 104.08,32.83 104.08,34.35
S$1609
  Top 1.778: 104.08,37.65 104.08,39.17
S$1610  (via drill 0.2)
  other vias: -25.6,42.4
S$1611  (via drill 0.2)
  other vias: -8.6,29.6
S$1612  (via drill 0.2)
  other vias: 8.6,42.4
S$1613  (via drill 0.2)
  other vias: 25.6,29.6
S$1614  (via drill 0.2)
  other vias: 41.6,42.4
S$1615  (via drill 0.2)
  other vias: 52.8,42.4
S$1616  (via drill 0.2)
  other vias: -41.6,29.6
S$1617  (via drill 0.2)
  other vias: -52.8,29.6
S$1618
  Bottom 0.8: 9.4,48.9 9.4,47.1
S$1619
  Bottom 0.8: 11.4,48.9 11.4,47.1
S$1620
  Bottom 0.8: 8.4,51.1 8.4,52.9
S$1621
  Bottom 0.8: 10.4,51.1 10.4,52.9
S$1622
  Bottom 0.8: 5.4,48.9 5.4,47.1
S$1623
  Bottom 0.8: 7.4,48.9 7.4,47.1
S$1624
  Bottom 0.8: 6.4,51.1 6.4,52.9
S$1625
  Bottom 0.8: 4.4,51.1 4.4,52.9
S$1626
  Bottom 0.8: 3.4,48.9 3.4,47.1
S$1627
  Bottom 0.8: 1.4,48.9 1.4,47.1
S$1628
  Bottom 0.8: 2.4,51.1 2.4,52.9
S$1629
  Bottom 0.8: 0.4,51.1 0.4,52.9
S$1630
  Bottom 0.8: -0.6,48.9 -0.6,47.1
S$1631
  Bottom 0.8: -2.6,48.9 -2.6,47.1
S$1632
  Bottom 0.8: -1.6,51.1 -1.6,52.9
S$1633
  Bottom 0.8: 17.4,48.9 17.4,47.1
S$1634
  Bottom 0.8: 19.4,48.9 19.4,47.1
S$1635
  Bottom 0.8: 16.4,51.1 16.4,52.9
S$1636
  Bottom 0.8: 18.4,51.1 18.4,52.9
S$1637
  Bottom 0.8: 13.4,48.9 13.4,47.1
S$1638
  Bottom 0.8: 15.4,48.9 15.4,47.1
S$1639
  Bottom 0.8: 12.4,51.1 12.4,52.9
S$1640
  Bottom 0.8: 14.4,51.1 14.4,52.9
S$1641
  Bottom 0.8: -7.4,56.9 -7.4,55.1
S$1642
  Bottom 0.8: -5.4,56.9 -5.4,55.1
S$1643
  Bottom 0.8: -8.4,59.1 -8.4,60.9
S$1644
  Bottom 0.8: -6.4,59.1 -6.4,60.9
S$1645
  Bottom 0.8: -11.4,56.9 -11.4,55.1
S$1646
  Bottom 0.8: -9.4,56.9 -9.4,55.1
S$1647
  Bottom 0.8: -10.4,59.1 -10.4,60.9
S$1648
  Bottom 0.8: -12.4,59.1 -12.4,60.9
S$1649
  Bottom 0.8: -13.4,56.9 -13.4,55.1
S$1650
  Bottom 0.8: -15.4,56.9 -15.4,55.1
S$1651
  Bottom 0.8: -14.4,59.1 -14.4,60.9
S$1652
  Bottom 0.8: -16.4,59.1 -16.4,60.9
S$1653
  Bottom 0.8: -17.4,56.9 -17.4,55.1
S$1654
  Bottom 0.8: -19.4,56.9 -19.4,55.1
S$1655
  Bottom 0.8: -18.4,59.1 -18.4,60.9
S$1656
  Bottom 0.8: 0.6,56.9 0.6,55.1
S$1657
  Bottom 0.8: 2.6,56.9 2.6,55.1
S$1658
  Bottom 0.8: -0.4,59.1 -0.4,60.9
S$1659
  Bottom 0.8: 1.6,59.1 1.6,60.9
S$1660
  Bottom 0.8: -3.4,56.9 -3.4,55.1
S$1661
  Bottom 0.8: -1.4,56.9 -1.4,55.1
S$1662
  Bottom 0.8: -4.4,59.1 -4.4,60.9
S$1663
  Bottom 0.8: -2.4,59.1 -2.4,60.9
S$1664
  Bottom 0.8: -24.6,48.9 -24.6,47.1
S$1665
  Bottom 0.8: -22.6,48.9 -22.6,47.1
S$1666
  Bottom 0.8: -25.6,51.1 -25.6,52.9
S$1667
  Bottom 0.8: -23.6,51.1 -23.6,52.9
S$1668
  Bottom 0.8: -28.6,48.9 -28.6,47.1
S$1669
  Bottom 0.8: -26.6,48.9 -26.6,47.1
S$1670
  Bottom 0.8: -27.6,51.1 -27.6,52.9
S$1671
  Bottom 0.8: -29.6,51.1 -29.6,52.9
S$1672
  Bottom 0.8: -30.6,48.9 -30.6,47.1
S$1673
  Bottom 0.8: -32.6,48.9 -32.6,47.1
S$1674
  Bottom 0.8: -31.6,51.1 -31.6,52.9
S$1675
  Bottom 0.8: -33.6,51.1 -33.6,52.9
S$1676
  Bottom 0.8: -34.6,48.9 -34.6,47.1
S$1677
  Bottom 0.8: -36.6,48.9 -36.6,47.1
S$1678
  Bottom 0.8: -35.6,51.1 -35.6,52.9
S$1679
  Bottom 0.8: -16.6,48.9 -16.6,47.1
S$1680
  Bottom 0.8: -14.6,48.9 -14.6,47.1
S$1681
  Bottom 0.8: -17.6,51.1 -17.6,52.9
S$1682
  Bottom 0.8: -15.6,51.1 -15.6,52.9
S$1683
  Bottom 0.8: -20.6,48.9 -20.6,47.1
S$1684
  Bottom 0.8: -18.6,48.9 -18.6,47.1
S$1685
  Bottom 0.8: -21.6,51.1 -21.6,52.9
S$1686
  Bottom 0.8: -19.6,51.1 -19.6,52.9
S$1687
  Bottom 0.8: 26.6,56.9 26.6,55.1
S$1688
  Bottom 0.8: 28.6,56.9 28.6,55.1
S$1689
  Bottom 0.8: 25.6,59.1 25.6,60.9
S$1690
  Bottom 0.8: 27.6,59.1 27.6,60.9
S$1691
  Bottom 0.8: 22.6,56.9 22.6,55.1
S$1692
  Bottom 0.8: 24.6,56.9 24.6,55.1
S$1693
  Bottom 0.8: 23.6,59.1 23.6,60.9
S$1694
  Bottom 0.8: 21.6,59.1 21.6,60.9
S$1695
  Bottom 0.8: 20.6,56.9 20.6,55.1
S$1696
  Bottom 0.8: 18.6,56.9 18.6,55.1
S$1697
  Bottom 0.8: 19.6,59.1 19.6,60.9
S$1698
  Bottom 0.8: 17.6,59.1 17.6,60.9
S$1699
  Bottom 0.8: 16.6,56.9 16.6,55.1
S$1700
  Bottom 0.8: 14.6,56.9 14.6,55.1
S$1701
  Bottom 0.8: 15.6,59.1 15.6,60.9
S$1702
  Bottom 0.8: 34.6,56.9 34.6,55.1
S$1703
  Bottom 0.8: 36.6,56.9 36.6,55.1
S$1704
  Bottom 0.8: 33.6,59.1 33.6,60.9
S$1705
  Bottom 0.8: 35.6,59.1 35.6,60.9
S$1706
  Bottom 0.8: 30.6,56.9 30.6,55.1
S$1707
  Bottom 0.8: 32.6,56.9 32.6,55.1
S$1708
  Bottom 0.8: 29.6,59.1 29.6,60.9
S$1709
  Bottom 0.8: 31.6,59.1 31.6,60.9
S$1710
  Bottom 0.8: -41.8,56.9 -41.8,55.1
S$1711
  Bottom 0.8: -39.8,56.9 -39.8,55.1
S$1712
  Bottom 0.8: -42.8,59.1 -42.8,60.9
S$1713
  Bottom 0.8: -40.8,59.1 -40.8,60.9
S$1714
  Bottom 0.8: -45.8,56.9 -45.8,55.1
S$1715
  Bottom 0.8: -43.8,56.9 -43.8,55.1
S$1716
  Bottom 0.8: -44.8,59.1 -44.8,60.9
S$1717
  Bottom 0.8: -46.8,59.1 -46.8,60.9
S$1718
  Bottom 0.8: -47.8,56.9 -47.8,55.1
S$1719
  Bottom 0.8: -49.8,56.9 -49.8,55.1
S$1720
  Bottom 0.8: -48.8,59.1 -48.8,60.9
S$1721
  Bottom 0.8: -50.8,59.1 -50.8,60.9
S$1722
  Bottom 0.8: -51.8,56.9 -51.8,55.1
S$1723
  Bottom 0.8: -53.8,56.9 -53.8,55.1
S$1724
  Bottom 0.8: -52.8,59.1 -52.8,60.9
S$1725
  Bottom 0.8: -33.8,56.9 -33.8,55.1
S$1726
  Bottom 0.8: -31.8,56.9 -31.8,55.1
S$1727
  Bottom 0.8: -34.8,59.1 -34.8,60.9
S$1728
  Bottom 0.8: -32.8,59.1 -32.8,60.9
S$1729
  Bottom 0.8: -37.8,56.9 -37.8,55.1
S$1730
  Bottom 0.8: -35.8,56.9 -35.8,55.1
S$1731
  Bottom 0.8: -38.8,59.1 -38.8,60.9
S$1732
  Bottom 0.8: -36.8,59.1 -36.8,60.9
S$1733
  Bottom 0.8: 43.8,48.9 43.8,47.1
S$1734
  Bottom 0.8: 45.8,48.9 45.8,47.1
S$1735
  Bottom 0.8: 42.8,51.1 42.8,52.9
S$1736
  Bottom 0.8: 44.8,51.1 44.8,52.9
S$1737
  Bottom 0.8: 39.8,48.9 39.8,47.1
S$1738
  Bottom 0.8: 41.8,48.9 41.8,47.1
S$1739
  Bottom 0.8: 40.8,51.1 40.8,52.9
S$1740
  Bottom 0.8: 38.8,51.1 38.8,52.9
S$1741
  Bottom 0.8: 37.8,48.9 37.8,47.1
S$1742
  Bottom 0.8: 35.8,48.9 35.8,47.1
S$1743
  Bottom 0.8: 36.8,51.1 36.8,52.9
S$1744
  Bottom 0.8: 34.8,51.1 34.8,52.9
S$1745
  Bottom 0.8: 33.8,48.9 33.8,47.1
S$1746
  Bottom 0.8: 31.8,48.9 31.8,47.1
S$1747
  Bottom 0.8: 32.8,51.1 32.8,52.9
S$1748
  Bottom 0.8: 51.8,48.9 51.8,47.1
S$1749
  Bottom 0.8: 53.8,48.9 53.8,47.1
S$1750
  Bottom 0.8: 50.8,51.1 50.8,52.9
S$1751
  Bottom 0.8: 52.8,51.1 52.8,52.9
S$1752
  Bottom 0.8: 47.8,48.9 47.8,47.1
S$1753
  Bottom 0.8: 49.8,48.9 49.8,47.1
S$1754
  Bottom 0.8: 46.8,51.1 46.8,52.9
S$1755
  Bottom 0.8: 48.8,51.1 48.8,52.9
S$1756  (via drill 0.2)
  other vias: -50.8,58
S$1757  (via drill 0.2)
  other vias: -49.2,58
S$1758  (via drill 0.2)
  other vias: -47.6,58
S$1759  (via drill 0.2)
  other vias: -46,58
S$1760  (via drill 0.2)
  other vias: -44.4,58
S$1761  (via drill 0.2)
  other vias: -42.8,58
S$1762  (via drill 0.2)
  other vias: -41.2,58
S$1763  (via drill 0.2)
  other vias: -39.6,58
S$1764  (via drill 0.2)
  other vias: -38,58
S$1765  (via drill 0.2)
  other vias: -36.4,58
S$1766  (via drill 0.2)
  other vias: -34.8,58
S$1767  (via drill 0.2)
  other vias: -50,54
S$1768  (via drill 0.2)
  other vias: -48.4,54
S$1769  (via drill 0.2)
  other vias: -46.8,54
S$1770  (via drill 0.2)
  other vias: -45.2,54
S$1771  (via drill 0.2)
  other vias: -43.6,54
S$1772  (via drill 0.2)
  other vias: -42,54
S$1773  (via drill 0.2)
  other vias: -40.4,54
S$1774  (via drill 0.2)
  other vias: -38.8,54
S$1775  (via drill 0.2)
  other vias: -37.2,54
S$1776  (via drill 0.2)
  other vias: -35.6,54
S$1777  (via drill 0.2)
  other vias: -34,50
S$1778  (via drill 0.2)
  other vias: -32.4,50
S$1779  (via drill 0.2)
  other vias: -30.8,50
S$1780  (via drill 0.2)
  other vias: -29.2,50
S$1781  (via drill 0.2)
  other vias: -27.6,50
S$1782  (via drill 0.2)
  other vias: -33.2,54
S$1783  (via drill 0.2)
  other vias: -31.6,54
S$1784  (via drill 0.2)
  other vias: -30,54
S$1785  (via drill 0.2)
  other vias: -28.4,54
S$1786  (via drill 0.2)
  other vias: -26.8,54
S$1787  (via drill 0.2)
  other vias: -26,50
S$1788  (via drill 0.2)
  other vias: -0.4,58
S$1789  (via drill 0.2)
  other vias: -2,58
S$1790  (via drill 0.2)
  other vias: -3.6,58
S$1791  (via drill 0.2)
  other vias: -5.2,58
S$1792  (via drill 0.2)
  other vias: -6.8,58
S$1793  (via drill 0.2)
  other vias: -8.4,58
S$1794  (via drill 0.2)
  other vias: -10,58
S$1795  (via drill 0.2)
  other vias: -11.6,58
S$1796  (via drill 0.2)
  other vias: -13.2,58
S$1797  (via drill 0.2)
  other vias: -14.8,58
S$1798  (via drill 0.2)
  other vias: -16.4,58
S$1799  (via drill 0.2)
  other vias: -1.2,54
S$1800  (via drill 0.2)
  other vias: -2.8,54
S$1801  (via drill 0.2)
  other vias: -4.4,54
S$1802  (via drill 0.2)
  other vias: -6,54
S$1803  (via drill 0.2)
  other vias: -7.6,54
S$1804  (via drill 0.2)
  other vias: -9.2,54
S$1805  (via drill 0.2)
  other vias: -10.8,54
S$1806  (via drill 0.2)
  other vias: -12.4,54
S$1807  (via drill 0.2)
  other vias: -14,54
S$1808  (via drill 0.2)
  other vias: -15.6,54
S$1809  (via drill 0.2)
  other vias: -17.2,50
S$1810  (via drill 0.2)
  other vias: -18.8,50
S$1811  (via drill 0.2)
  other vias: -20.4,50
S$1812  (via drill 0.2)
  other vias: -22,50
S$1813  (via drill 0.2)
  other vias: -23.6,50
S$1814  (via drill 0.2)
  other vias: -18,54
S$1815  (via drill 0.2)
  other vias: -19.6,54
S$1816  (via drill 0.2)
  other vias: -21.2,54
S$1817  (via drill 0.2)
  other vias: -22.8,54
S$1818  (via drill 0.2)
  other vias: -24.4,54
S$1819  (via drill 0.2)
  other vias: -25.2,50
S$1820  (via drill 0.2)
  other vias: 0.4,54
S$1821  (via drill 0.2)
  other vias: 2,54
S$1822  (via drill 0.2)
  other vias: 3.6,54
S$1823  (via drill 0.2)
  other vias: 5.2,54
S$1824  (via drill 0.2)
  other vias: 6.8,54
S$1825  (via drill 0.2)
  other vias: 8.4,54
S$1826  (via drill 0.2)
  other vias: 10,54
S$1827  (via drill 0.2)
  other vias: 11.6,54
S$1828  (via drill 0.2)
  other vias: 13.2,54
S$1829  (via drill 0.2)
  other vias: 14.8,54
S$1830  (via drill 0.2)
  other vias: 16.4,50
S$1831  (via drill 0.2)
  other vias: 1.2,50
S$1832  (via drill 0.2)
  other vias: 2.8,50
S$1833  (via drill 0.2)
  other vias: 4.4,50
S$1834  (via drill 0.2)
  other vias: 6,50
S$1835  (via drill 0.2)
  other vias: 7.6,50
S$1836  (via drill 0.2)
  other vias: 9.2,50
S$1837  (via drill 0.2)
  other vias: 10.8,50
S$1838  (via drill 0.2)
  other vias: 12.4,50
S$1839  (via drill 0.2)
  other vias: 14,50
S$1840  (via drill 0.2)
  other vias: 15.6,50
S$1841  (via drill 0.2)
  other vias: 17.2,54
S$1842  (via drill 0.2)
  other vias: 18.8,54
S$1843  (via drill 0.2)
  other vias: 20.4,54
S$1844  (via drill 0.2)
  other vias: 18,58
S$1845  (via drill 0.2)
  other vias: 19.6,58
S$1846  (via drill 0.2)
  other vias: 21.2,58
S$1847  (via drill 0.2)
  other vias: 22,54
S$1848  (via drill 0.2)
  other vias: 22.8,58
S$1849  (via drill 0.2)
  other vias: 23.6,54
S$1850  (via drill 0.2)
  other vias: 24.4,58
S$1851  (via drill 0.2)
  other vias: 25.2,54
S$1852  (via drill 0.2)
  other vias: 50.8,54
S$1853  (via drill 0.2)
  other vias: 49.2,54
S$1854  (via drill 0.2)
  other vias: 47.6,54
S$1855  (via drill 0.2)
  other vias: 46,54
S$1856  (via drill 0.2)
  other vias: 44.4,54
S$1857  (via drill 0.2)
  other vias: 42.8,54
S$1858  (via drill 0.2)
  other vias: 41.2,54
S$1859  (via drill 0.2)
  other vias: 39.6,54
S$1860  (via drill 0.2)
  other vias: 38,54
S$1861  (via drill 0.2)
  other vias: 36.4,54
S$1862  (via drill 0.2)
  other vias: 34.8,50
S$1863  (via drill 0.2)
  other vias: 50,50
S$1864  (via drill 0.2)
  other vias: 48.4,50
S$1865  (via drill 0.2)
  other vias: 46.8,50
S$1866  (via drill 0.2)
  other vias: 45.2,50
S$1867  (via drill 0.2)
  other vias: 43.6,50
S$1868  (via drill 0.2)
  other vias: 42,50
S$1869  (via drill 0.2)
  other vias: 40.4,50
S$1870  (via drill 0.2)
  other vias: 38.8,50
S$1871  (via drill 0.2)
  other vias: 37.2,50
S$1872  (via drill 0.2)
  other vias: 35.6,50
S$1873  (via drill 0.2)
  other vias: 34,54
S$1874  (via drill 0.2)
  other vias: 32.4,54
S$1875  (via drill 0.2)
  other vias: 30.8,54
S$1876  (via drill 0.2)
  other vias: 33.2,58
S$1877  (via drill 0.2)
  other vias: 31.6,58
S$1878  (via drill 0.2)
  other vias: 30,58
S$1879  (via drill 0.2)
  other vias: 29.2,54
S$1880  (via drill 0.2)
  other vias: 28.4,58
S$1881  (via drill 0.2)
  other vias: 27.6,54
S$1882  (via drill 0.2)
  other vias: 26.8,58
S$1883  (via drill 0.2)
  other vias: 26,54
S$1884
  Bottom 0.152: -52.8,59 -51.8,58
S$1885
  Bottom 0.152: -51.8,58 -50.8,58
S$1886
  Bottom 0.152: -50.8,59 -50.2,59
S$1887
  Bottom 0.152: -50.2,59 -49.2,58
S$1888
  Bottom 0.152: -48.8,59 -48.6,59
S$1889
  Bottom 0.152: -48.6,59 -47.6,58
S$1890
  Bottom 0.152: -46.8,59 -46,58.2
S$1891
  Bottom 0.152: -46,58.2 -46,58
S$1892
  Bottom 0.152: -44.8,59 -44.4,58.6
S$1893
  Bottom 0.152: -44.4,58.6 -44.4,58
S$1894
  Bottom 0.152: -42.8,59 -42.8,58
S$1895
  Bottom 0.152: -40.8,59 -41.2,58.6
S$1896
  Bottom 0.152: -41.2,58.6 -41.2,58
S$1897
  Bottom 0.152: -38.8,59 -39.6,58.2
S$1898
  Bottom 0.152: -39.6,58.2 -39.6,58
S$1899
  Bottom 0.152: -36.8,59 -37,59
S$1900
  Bottom 0.152: -37,59 -38,58
S$1901
  Bottom 0.152: -34.8,59 -35.4,59
S$1902
  Bottom 0.152: -35.4,59 -36.4,58
S$1903
  Bottom 0.152: -32.8,59 -33.8,58
S$1904
  Bottom 0.152: -33.8,58 -34.8,58
S$1905
  Bottom 0.152: -51.8,55 -50.8,54
S$1906
  Bottom 0.152: -50.8,54 -50,54
S$1907
  Bottom 0.152: -49.8,55 -48.8,54
S$1908
  Bottom 0.152: -48.8,54 -48.4,54
S$1909
  Bottom 0.152: -47.8,55 -46.8,54
S$1910
  Bottom 0.152: -45.8,55 -45.2,54.4
S$1911
  Bottom 0.152: -45.2,54.4 -45.2,54
S$1912
  Bottom 0.152: -43.8,55 -43.6,54.8
S$1913
  Bottom 0.152: -43.6,54.8 -43.6,54
S$1914
  Bottom 0.152: -41.8,55 -42,54.8
S$1915
  Bottom 0.152: -42,54.8 -42,54
S$1916
  Bottom 0.152: -39.8,55 -40.4,54.4
S$1917
  Bottom 0.152: -40.4,54.4 -40.4,54
S$1918
  Bottom 0.152: -37.8,55 -38.8,54
S$1919
  Bottom 0.152: -35.8,55 -36.8,54
S$1920
  Bottom 0.152: -36.8,54 -37.2,54
S$1921
  Bottom 0.152: -33.8,55 -34.8,54
S$1922
  Bottom 0.152: -34.8,54 -35.6,54
S$1923
  Bottom 0.152: -36.6,49 -35.6,50
S$1924
  Bottom 0.152: -35.6,50 -34,50
S$1925
  Bottom 0.152: -34.6,49 -33.8,49
S$1926
  Bottom 0.152: -33.8,49 -32.8,50
S$1927
  Bottom 0.152: -32.8,50 -32.4,50
S$1928
  Bottom 0.152: -32.6,49 -31.8,49
S$1929
  Bottom 0.152: -31.8,49 -30.8,50
S$1930
  Bottom 0.152: -30.6,49 -30.2,49
S$1931
  Bottom 0.152: -30.2,49 -29.2,50
S$1932
  Bottom 0.152: -28.6,49 -27.6,50
S$1933
  Bottom 0.152: -26.6,49 -26,49.6
S$1934
  Bottom 0.152: -26,49.6 -26,50
S$1935
  Bottom 0.152: -35.6,53 -35,53
S$1936
  Bottom 0.152: -35,53 -34,54
S$1937
  Bottom 0.152: -34,54 -33.2,54
S$1938
  Bottom 0.152: -33.6,53 -33,53
S$1939
  Bottom 0.152: -33,53 -32,54
S$1940
  Bottom 0.152: -32,54 -31.6,54
S$1941
  Bottom 0.152: -31.6,53 -31,53
S$1942
  Bottom 0.152: -31,53 -30,54
S$1943
  Bottom 0.152: -29.6,53 -29.4,53
S$1944
  Bottom 0.152: -29.4,53 -28.4,54
S$1945
  Bottom 0.152: -27.6,53 -26.8,53.8
S$1946
  Bottom 0.152: -26.8,53.8 -26.8,54
S$1947
  Bottom 0.152: 1.6,59 0.6,58
S$1948
  Bottom 0.152: 0.6,58 -0.4,58
S$1949
  Bottom 0.152: -0.4,59 -1,59
S$1950
  Bottom 0.152: -1,59 -2,58
S$1951
  Bottom 0.152: -2.4,59 -2.6,59
S$1952
  Bottom 0.152: -2.6,59 -3.6,58
S$1953
  Bottom 0.152: -4.4,59 -5.2,58.2
S$1954
  Bottom 0.152: -5.2,58.2 -5.2,58
S$1955
  Bottom 0.152: -6.4,59 -6.8,58.6
S$1956
  Bottom 0.152: -6.8,58.6 -6.8,58
S$1957
  Bottom 0.152: -8.4,59 -8.4,58
S$1958
  Bottom 0.152: -10.4,59 -10,58.6
S$1959
  Bottom 0.152: -10,58.6 -10,58
S$1960
  Bottom 0.152: -12.4,59 -11.6,58.2
S$1961
  Bottom 0.152: -11.6,58.2 -11.6,58
S$1962
  Bottom 0.152: -14.4,59 -14.2,59
S$1963
  Bottom 0.152: -14.2,59 -13.2,58
S$1964
  Bottom 0.152: -16.4,59 -15.8,59
S$1965
  Bottom 0.152: -15.8,59 -14.8,58
S$1966
  Bottom 0.152: -18.4,59 -17.4,58
S$1967
  Bottom 0.152: -17.4,58 -16.4,58
S$1968
  Bottom 0.152: 0.6,55 -0.4,54
S$1969
  Bottom 0.152: -0.4,54 -1.2,54
S$1970
  Bottom 0.152: -1.4,55 -2.4,54
S$1971
  Bottom 0.152: -2.4,54 -2.8,54
S$1972
  Bottom 0.152: -3.4,55 -4.4,54
S$1973
  Bottom 0.152: -5.4,55 -6,54.4
S$1974
  Bottom 0.152: -6,54.4 -6,54
S$1975
  Bottom 0.152: -7.4,55 -7.6,54.8
S$1976
  Bottom 0.152: -7.6,54.8 -7.6,54
S$1977
  Bottom 0.152: -9.4,55 -9.2,54.8
S$1978
  Bottom 0.152: -9.2,54.8 -9.2,54
S$1979
  Bottom 0.152: -11.4,55 -10.8,54.4
S$1980
  Bottom 0.152: -10.8,54.4 -10.8,54
S$1981
  Bottom 0.152: -13.4,55 -12.4,54
S$1982
  Bottom 0.152: -15.4,55 -14.4,54
S$1983
  Bottom 0.152: -14.4,54 -14,54
S$1984
  Bottom 0.152: -17.4,55 -16.4,54
S$1985
  Bottom 0.152: -16.4,54 -15.6,54
S$1986
  Bottom 0.152: -14.6,49 -15.6,50
S$1987
  Bottom 0.152: -15.6,50 -17.2,50
S$1988
  Bottom 0.152: -16.6,49 -17.4,49
S$1989
  Bottom 0.152: -17.4,49 -18.4,50
S$1990
  Bottom 0.152: -18.4,50 -18.8,50
S$1991
  Bottom 0.152: -18.6,49 -19.4,49
S$1992
  Bottom 0.152: -19.4,49 -20.4,50
S$1993
  Bottom 0.152: -20.6,49 -21,49
S$1994
  Bottom 0.152: -21,49 -22,50
S$1995
  Bottom 0.152: -22.6,49 -23.6,50
S$1996
  Bottom 0.152: -24.6,49 -25.2,49.6
S$1997
  Bottom 0.152: -25.2,49.6 -25.2,50
S$1998
  Bottom 0.152: -15.6,53 -16.2,53
S$1999
  Bottom 0.152: -16.2,53 -17.2,54
S$2000
  Bottom 0.152: -17.2,54 -18,54
S$2001
  Bottom 0.152: -17.6,53 -18.2,53
S$2002
  Bottom 0.152: -18.2,53 -19.2,54
S$2003
  Bottom 0.152: -19.2,54 -19.6,54
S$2004
  Bottom 0.152: -19.6,53 -20.2,53
S$2005
  Bottom 0.152: -20.2,53 -21.2,54
S$2006
  Bottom 0.152: -21.6,53 -21.8,53
S$2007
  Bottom 0.152: -21.8,53 -22.8,54
S$2008
  Bottom 0.152: -23.6,53 -24.4,53.8
S$2009
  Bottom 0.152: -24.4,53.8 -24.4,54
S$2010
  Bottom 0.152: 0.4,53 1,53
S$2011
  Bottom 0.152: 1,53 2,54
S$2012
  Bottom 0.152: 2.4,53 2.6,53
S$2013
  Bottom 0.152: 2.6,53 3.6,54
S$2014
  Bottom 0.152: 4.4,53 5.2,53.8
S$2015
  Bottom 0.152: 5.2,53.8 5.2,54
S$2016
  Bottom 0.152: 6.4,53 6.8,53.4
S$2017
  Bottom 0.152: 6.8,53.4 6.8,54
S$2018
  Bottom 0.152: 8.4,53 8.4,54
S$2019
  Bottom 0.152: -1.6,53 -0.6,53
S$2020
  Bottom 0.152: -0.6,53 0.4,54
S$2021
  Bottom 0.152: -0.6,49 0.4,50
S$2022
  Bottom 0.152: 0.4,50 1.2,50
S$2023
  Bottom 0.152: 1.4,49 1.8,49
S$2024
  Bottom 0.152: 1.8,49 2.8,50
S$2025
  Bottom 0.152: 3.4,49 4.4,50
S$2026
  Bottom 0.152: 5.4,49 6,49.6
S$2027
  Bottom 0.152: 6,49.6 6,50
S$2028
  Bottom 0.152: 7.4,49 7.6,49.2
S$2029
  Bottom 0.152: 7.6,49.2 7.6,50
S$2030
  Bottom 0.152: 9.4,49 9.2,49.2
S$2031
  Bottom 0.152: 9.2,49.2 9.2,50
S$2032
  Bottom 0.152: 11.4,49 10.8,49.6
S$2033
  Bottom 0.152: 10.8,49.6 10.8,50
S$2034
  Bottom 0.152: 13.4,49 12.4,50
S$2035
  Bottom 0.152: 15.4,49 15,49
S$2036
  Bottom 0.152: 15,49 14,50
S$2037
  Bottom 0.152: 17.4,49 16.6,49
S$2038
  Bottom 0.152: 16.6,49 15.6,50
S$2039
  Bottom 0.152: 10.4,53 10,53.4
S$2040
  Bottom 0.152: 10,53.4 10,54
S$2041
  Bottom 0.152: 12.4,53 11.6,53.8
S$2042
  Bottom 0.152: 11.6,53.8 11.6,54
S$2043
  Bottom 0.152: 14.4,53 14.2,53
S$2044
  Bottom 0.152: 14.2,53 13.2,54
S$2045
  Bottom 0.152: 16.4,53 15.8,53
S$2046
  Bottom 0.152: 15.8,53 14.8,54
S$2047
  Bottom 0.152: 18.4,51 17.4,50
S$2048
  Bottom 0.152: 17.4,50 16.4,50
S$2049
  Bottom 0.152: 16.6,55 17.2,55
S$2050
  Bottom 0.152: 17.2,55 18.2,54
S$2051
  Bottom 0.152: 18.2,54 18.8,54
S$2052
  Bottom 0.152: 18.6,55 19.6,54
S$2053
  Bottom 0.152: 19.6,54 20.4,54
S$2054
  Bottom 0.152: 20.6,55 21.6,54
S$2055
  Bottom 0.152: 21.6,54 22,54
S$2056
  Bottom 0.152: 22.6,55 23.6,54
S$2057
  Bottom 0.152: 24.6,55 25.2,54.4
S$2058
  Bottom 0.152: 25.2,54.4 25.2,54
S$2059
  Bottom 0.152: 15.6,59 16.6,58
S$2060
  Bottom 0.152: 16.6,58 18,58
S$2061
  Bottom 0.152: 17.6,59 18,59
S$2062
  Bottom 0.152: 18,59 19,58
S$2063
  Bottom 0.152: 19,58 19.6,58
S$2064
  Bottom 0.152: 19.6,59 20.2,59
S$2065
  Bottom 0.152: 20.2,59 21.2,58
S$2066
  Bottom 0.152: 21.6,59 21.8,59
S$2067
  Bottom 0.152: 21.8,59 22.8,58
S$2068
  Bottom 0.152: 23.6,59 24.4,58.2
S$2069
  Bottom 0.152: 24.4,58.2 24.4,58
S$2070
  Bottom 0.152: 17.2,54 16,54
S$2071
  Bottom 0.152: 16,54 15,55
S$2072
  Bottom 0.152: 15,55 14.6,55
S$2073
  Bottom 0.152: 50.8,53 50.2,53
S$2074
  Bottom 0.152: 50.2,53 49.2,54
S$2075
  Bottom 0.152: 48.8,53 48.6,53
S$2076
  Bottom 0.152: 48.6,53 47.6,54
S$2077
  Bottom 0.152: 46.8,53 46,53.8
S$2078
  Bottom 0.152: 46,53.8 46,54
S$2079
  Bottom 0.152: 44.8,53 44.4,53.4
S$2080
  Bottom 0.152: 44.4,53.4 44.4,54
S$2081
  Bottom 0.152: 42.8,53 42.8,54
S$2082
  Bottom 0.152: 52.8,53 51.8,53
S$2083
  Bottom 0.152: 51.8,53 50.8,54
S$2084
  Bottom 0.152: 51.8,49 50.8,50
S$2085
  Bottom 0.152: 50.8,50 50,50
S$2086
  Bottom 0.152: 49.8,49 49.4,49
S$2087
  Bottom 0.152: 49.4,49 48.4,50
S$2088
  Bottom 0.152: 47.8,49 46.8,50
S$2089
  Bottom 0.152: 45.8,49 45.2,49.6
S$2090
  Bottom 0.152: 45.2,49.6 45.2,50
S$2091
  Bottom 0.152: 43.8,49 43.6,49.2
S$2092
  Bottom 0.152: 43.6,49.2 43.6,50
S$2093
  Bottom 0.152: 41.8,49 42,49.2
S$2094
  Bottom 0.152: 42,49.2 42,50
S$2095
  Bottom 0.152: 39.8,49 40.4,49.6
S$2096
  Bottom 0.152: 40.4,49.6 40.4,50
S$2097
  Bottom 0.152: 37.8,49 38.8,50
S$2098
  Bottom 0.152: 35.8,49 36.2,49
S$2099
  Bottom 0.152: 36.2,49 37.2,50
S$2100
  Bottom 0.152: 33.8,49 34.6,49
S$2101
  Bottom 0.152: 34.6,49 35.6,50
S$2102
  Bottom 0.152: 40.8,53 41.2,53.4
S$2103
  Bottom 0.152: 41.2,53.4 41.2,54
S$2104
  Bottom 0.152: 38.8,53 39.6,53.8
S$2105
  Bottom 0.152: 39.6,53.8 39.6,54
S$2106
  Bottom 0.152: 36.8,53 37,53
S$2107
  Bottom 0.152: 37,53 38,54
S$2108
  Bottom 0.152: 34.8,53 35.4,53
S$2109
  Bottom 0.152: 35.4,53 36.4,54
S$2110
  Bottom 0.152: 32.8,51 33.8,50
S$2111
  Bottom 0.152: 33.8,50 34.8,50
S$2112
  Bottom 0.152: 34.6,55 34,55
S$2113
  Bottom 0.152: 34,55 33,54
S$2114
  Bottom 0.152: 33,54 32.4,54
S$2115
  Bottom 0.152: 32.6,55 31.6,54
S$2116
  Bottom 0.152: 31.6,54 30.8,54
S$2117
  Bottom 0.152: 30.6,55 29.6,54
S$2118
  Bottom 0.152: 29.6,54 29.2,54
S$2119
  Bottom 0.152: 28.6,55 27.6,54
S$2120
  Bottom 0.152: 26.6,55 26,54.4
S$2121
  Bottom 0.152: 26,54.4 26,54
S$2122
  Bottom 0.152: 35.6,59 34.6,58
S$2123
  Bottom 0.152: 34.6,58 33.2,58
S$2124
  Bottom 0.152: 33.6,59 33.2,59
S$2125
  Bottom 0.152: 33.2,59 32.2,58
S$2126
  Bottom 0.152: 32.2,58 31.6,58
S$2127
  Bottom 0.152: 31.6,59 31,59
S$2128
  Bottom 0.152: 31,59 30,58
S$2129
  Bottom 0.152: 29.6,59 29.4,59
S$2130
  Bottom 0.152: 29.4,59 28.4,58
S$2131
  Bottom 0.152: 27.6,59 26.8,58.2
S$2132
  Bottom 0.152: 26.8,58.2 26.8,58
S$2133
  Bottom 0.152: 34,54 35.2,54
S$2134
  Bottom 0.152: 35.2,54 36.2,55
S$2135
  Bottom 0.152: 36.2,55 36.6,55
S$2136  (2 unrouted)
  Top 0.813: 65,58.5 65,49.5
  Top 1.8: 66,55.5 64,55.5 | 66,58.5 65,58.5 64,58.5 | 66,52.5 64,52.5 | 66,49.5 65,49.5 64,49.5
S$2137
  Top 1.778: -104.08,50.83 -104.08,52.35
S$2138
  Top 1.778: -104.08,55.65 -104.08,57.17
S$2139
  Top 1.778: -99,50.83 -99,52.35
S$2140
  Top 1.778: -99,55.65 -99,57.17
S$2141
  Top 1.778: -93.92,50.83 -93.92,52.35
S$2142
  Top 1.778: -93.92,55.65 -93.92,57.17
S$2143
  Top 1.778: 93.92,50.83 93.92,52.35
S$2144
  Top 1.778: 93.92,55.65 93.92,57.17
S$2145
  Top 1.778: 99,50.83 99,52.35
S$2146
  Top 1.778: 99,55.65 99,57.17
S$2147
  Top 1.778: 104.08,50.83 104.08,52.35
S$2148
  Top 1.778: 104.08,55.65 104.08,57.17
S$2149  (via drill 0.2)
  other vias: -25.6,60.4
S$2150  (via drill 0.2)
  other vias: -8.6,47.6
S$2151  (via drill 0.2)
  other vias: 8.6,60.4
S$2152  (via drill 0.2)
  other vias: 25.6,47.6
S$2153  (via drill 0.2)
  other vias: 41.6,60.4
S$2154  (via drill 0.2)
  other vias: 52.8,60.4
S$2155  (via drill 0.2)
  other vias: -41.6,47.6
S$2156  (via drill 0.2)
  other vias: -52.8,47.6
S$2157
  Bottom 0.8: 9.4,66.9 9.4,65.1
S$2158
  Bottom 0.8: 11.4,66.9 11.4,65.1
S$2159
  Bottom 0.8: 8.4,69.1 8.4,70.9
S$2160
  Bottom 0.8: 10.4,69.1 10.4,70.9
S$2161
  Bottom 0.8: 5.4,66.9 5.4,65.1
S$2162
  Bottom 0.8: 7.4,66.9 7.4,65.1
S$2163
  Bottom 0.8: 6.4,69.1 6.4,70.9
S$2164
  Bottom 0.8: 4.4,69.1 4.4,70.9
S$2165
  Bottom 0.8: 3.4,66.9 3.4,65.1
S$2166
  Bottom 0.8: 1.4,66.9 1.4,65.1
S$2167
  Bottom 0.8: 2.4,69.1 2.4,70.9
S$2168
  Bottom 0.8: 0.4,69.1 0.4,70.9
S$2169
  Bottom 0.8: -0.6,66.9 -0.6,65.1
S$2170
  Bottom 0.8: -2.6,66.9 -2.6,65.1
S$2171
  Bottom 0.8: -1.6,69.1 -1.6,70.9
S$2172
  Bottom 0.8: 17.4,66.9 17.4,65.1
S$2173
  Bottom 0.8: 19.4,66.9 19.4,65.1
S$2174
  Bottom 0.8: 16.4,69.1 16.4,70.9
S$2175
  Bottom 0.8: 18.4,69.1 18.4,70.9
S$2176
  Bottom 0.8: 13.4,66.9 13.4,65.1
S$2177
  Bottom 0.8: 15.4,66.9 15.4,65.1
S$2178
  Bottom 0.8: 12.4,69.1 12.4,70.9
S$2179
  Bottom 0.8: 14.4,69.1 14.4,70.9
S$2180
  Bottom 0.8: -7.4,74.9 -7.4,73.1
S$2181
  Bottom 0.8: -5.4,74.9 -5.4,73.1
S$2182
  Bottom 0.8: -8.4,77.1 -8.4,78.9
S$2183
  Bottom 0.8: -6.4,77.1 -6.4,78.9
S$2184
  Bottom 0.8: -11.4,74.9 -11.4,73.1
S$2185
  Bottom 0.8: -9.4,74.9 -9.4,73.1
S$2186
  Bottom 0.8: -10.4,77.1 -10.4,78.9
S$2187
  Bottom 0.8: -12.4,77.1 -12.4,78.9
S$2188
  Bottom 0.8: -13.4,74.9 -13.4,73.1
S$2189
  Bottom 0.8: -15.4,74.9 -15.4,73.1
S$2190
  Bottom 0.8: -14.4,77.1 -14.4,78.9
S$2191
  Bottom 0.8: -16.4,77.1 -16.4,78.9
S$2192
  Bottom 0.8: -17.4,74.9 -17.4,73.1
S$2193
  Bottom 0.8: -19.4,74.9 -19.4,73.1
S$2194
  Bottom 0.8: -18.4,77.1 -18.4,78.9
S$2195
  Bottom 0.8: 0.6,74.9 0.6,73.1
S$2196
  Bottom 0.8: 2.6,74.9 2.6,73.1
S$2197
  Bottom 0.8: -0.4,77.1 -0.4,78.9
S$2198
  Bottom 0.8: 1.6,77.1 1.6,78.9
S$2199
  Bottom 0.8: -3.4,74.9 -3.4,73.1
S$2200
  Bottom 0.8: -1.4,74.9 -1.4,73.1
S$2201
  Bottom 0.8: -4.4,77.1 -4.4,78.9
S$2202
  Bottom 0.8: -2.4,77.1 -2.4,78.9
S$2203
  Bottom 0.8: -24.6,66.9 -24.6,65.1
S$2204
  Bottom 0.8: -22.6,66.9 -22.6,65.1
S$2205
  Bottom 0.8: -25.6,69.1 -25.6,70.9
S$2206
  Bottom 0.8: -23.6,69.1 -23.6,70.9
S$2207
  Bottom 0.8: -28.6,66.9 -28.6,65.1
S$2208
  Bottom 0.8: -26.6,66.9 -26.6,65.1
S$2209
  Bottom 0.8: -27.6,69.1 -27.6,70.9
S$2210
  Bottom 0.8: -29.6,69.1 -29.6,70.9
S$2211
  Bottom 0.8: -30.6,66.9 -30.6,65.1
S$2212
  Bottom 0.8: -32.6,66.9 -32.6,65.1
S$2213
  Bottom 0.8: -31.6,69.1 -31.6,70.9
S$2214
  Bottom 0.8: -33.6,69.1 -33.6,70.9
S$2215
  Bottom 0.8: -34.6,66.9 -34.6,65.1
S$2216
  Bottom 0.8: -36.6,66.9 -36.6,65.1
S$2217
  Bottom 0.8: -35.6,69.1 -35.6,70.9
S$2218
  Bottom 0.8: -16.6,66.9 -16.6,65.1
S$2219
  Bottom 0.8: -14.6,66.9 -14.6,65.1
S$2220
  Bottom 0.8: -17.6,69.1 -17.6,70.9
S$2221
  Bottom 0.8: -15.6,69.1 -15.6,70.9
S$2222
  Bottom 0.8: -20.6,66.9 -20.6,65.1
S$2223
  Bottom 0.8: -18.6,66.9 -18.6,65.1
S$2224
  Bottom 0.8: -21.6,69.1 -21.6,70.9
S$2225
  Bottom 0.8: -19.6,69.1 -19.6,70.9
S$2226
  Bottom 0.8: 26.6,74.9 26.6,73.1
S$2227
  Bottom 0.8: 28.6,74.9 28.6,73.1
S$2228
  Bottom 0.8: 25.6,77.1 25.6,78.9
S$2229
  Bottom 0.8: 27.6,77.1 27.6,78.9
S$2230
  Bottom 0.8: 22.6,74.9 22.6,73.1
S$2231
  Bottom 0.8: 24.6,74.9 24.6,73.1
S$2232
  Bottom 0.8: 23.6,77.1 23.6,78.9
S$2233
  Bottom 0.8: 21.6,77.1 21.6,78.9
S$2234
  Bottom 0.8: 20.6,74.9 20.6,73.1
S$2235
  Bottom 0.8: 18.6,74.9 18.6,73.1
S$2236
  Bottom 0.8: 19.6,77.1 19.6,78.9
S$2237
  Bottom 0.8: 17.6,77.1 17.6,78.9
S$2238
  Bottom 0.8: 16.6,74.9 16.6,73.1
S$2239
  Bottom 0.8: 14.6,74.9 14.6,73.1
S$2240
  Bottom 0.8: 15.6,77.1 15.6,78.9
S$2241
  Bottom 0.8: 34.6,74.9 34.6,73.1
S$2242
  Bottom 0.8: 36.6,74.9 36.6,73.1
S$2243
  Bottom 0.8: 33.6,77.1 33.6,78.9
S$2244
  Bottom 0.8: 35.6,77.1 35.6,78.9
S$2245
  Bottom 0.8: 30.6,74.9 30.6,73.1
S$2246
  Bottom 0.8: 32.6,74.9 32.6,73.1
S$2247
  Bottom 0.8: 29.6,77.1 29.6,78.9
S$2248
  Bottom 0.8: 31.6,77.1 31.6,78.9
S$2249
  Bottom 0.8: -41.8,74.9 -41.8,73.1
S$2250
  Bottom 0.8: -39.8,74.9 -39.8,73.1
S$2251
  Bottom 0.8: -42.8,77.1 -42.8,78.9
S$2252
  Bottom 0.8: -40.8,77.1 -40.8,78.9
S$2253
  Bottom 0.8: -45.8,74.9 -45.8,73.1
S$2254
  Bottom 0.8: -43.8,74.9 -43.8,73.1
S$2255
  Bottom 0.8: -44.8,77.1 -44.8,78.9
S$2256
  Bottom 0.8: -46.8,77.1 -46.8,78.9
S$2257
  Bottom 0.8: -47.8,74.9 -47.8,73.1
S$2258
  Bottom 0.8: -49.8,74.9 -49.8,73.1
S$2259
  Bottom 0.8: -48.8,77.1 -48.8,78.9
S$2260
  Bottom 0.8: -50.8,77.1 -50.8,78.9
S$2261
  Bottom 0.8: -51.8,74.9 -51.8,73.1
S$2262
  Bottom 0.8: -53.8,74.9 -53.8,73.1
S$2263
  Bottom 0.8: -52.8,77.1 -52.8,78.9
S$2264
  Bottom 0.8: -33.8,74.9 -33.8,73.1
S$2265
  Bottom 0.8: -31.8,74.9 -31.8,73.1
S$2266
  Bottom 0.8: -34.8,77.1 -34.8,78.9
S$2267
  Bottom 0.8: -32.8,77.1 -32.8,78.9
S$2268
  Bottom 0.8: -37.8,74.9 -37.8,73.1
S$2269
  Bottom 0.8: -35.8,74.9 -35.8,73.1
S$2270
  Bottom 0.8: -38.8,77.1 -38.8,78.9
S$2271
  Bottom 0.8: -36.8,77.1 -36.8,78.9
S$2272
  Bottom 0.8: 43.8,66.9 43.8,65.1
S$2273
  Bottom 0.8: 45.8,66.9 45.8,65.1
S$2274
  Bottom 0.8: 42.8,69.1 42.8,70.9
S$2275
  Bottom 0.8: 44.8,69.1 44.8,70.9
S$2276
  Bottom 0.8: 39.8,66.9 39.8,65.1
S$2277
  Bottom 0.8: 41.8,66.9 41.8,65.1
S$2278
  Bottom 0.8: 40.8,69.1 40.8,70.9
S$2279
  Bottom 0.8: 38.8,69.1 38.8,70.9
S$2280
  Bottom 0.8: 37.8,66.9 37.8,65.1
S$2281
  Bottom 0.8: 35.8,66.9 35.8,65.1
S$2282
  Bottom 0.8: 36.8,69.1 36.8,70.9
S$2283
  Bottom 0.8: 34.8,69.1 34.8,70.9
S$2284
  Bottom 0.8: 33.8,66.9 33.8,65.1
S$2285
  Bottom 0.8: 31.8,66.9 31.8,65.1
S$2286
  Bottom 0.8: 32.8,69.1 32.8,70.9
S$2287
  Bottom 0.8: 51.8,66.9 51.8,65.1
S$2288
  Bottom 0.8: 53.8,66.9 53.8,65.1
S$2289
  Bottom 0.8: 50.8,69.1 50.8,70.9
S$2290
  Bottom 0.8: 52.8,69.1 52.8,70.9
S$2291
  Bottom 0.8: 47.8,66.9 47.8,65.1
S$2292
  Bottom 0.8: 49.8,66.9 49.8,65.1
S$2293
  Bottom 0.8: 46.8,69.1 46.8,70.9
S$2294
  Bottom 0.8: 48.8,69.1 48.8,70.9
S$2295  (via drill 0.2)
  other vias: -50.8,76
S$2296  (via drill 0.2)
  other vias: -49.2,76
S$2297  (via drill 0.2)
  other vias: -47.6,76
S$2298  (via drill 0.2)
  other vias: -46,76
S$2299  (via drill 0.2)
  other vias: -44.4,76
S$2300  (via drill 0.2)
  other vias: -42.8,76
S$2301  (via drill 0.2)
  other vias: -41.2,76
S$2302  (via drill 0.2)
  other vias: -39.6,76
S$2303  (via drill 0.2)
  other vias: -38,76
S$2304  (via drill 0.2)
  other vias: -36.4,76
S$2305  (via drill 0.2)
  other vias: -34.8,76
S$2306  (via drill 0.2)
  other vias: -50,72
S$2307  (via drill 0.2)
  other vias: -48.4,72
S$2308  (via drill 0.2)
  other vias: -46.8,72
S$2309  (via drill 0.2)
  other vias: -45.2,72
S$2310  (via drill 0.2)
  other vias: -43.6,72
S$2311  (via drill 0.2)
  other vias: -42,72
S$2312  (via drill 0.2)
  other vias: -40.4,72
S$2313  (via drill 0.2)
  other vias: -38.8,72
S$2314  (via drill 0.2)
  other vias: -37.2,72
S$2315  (via drill 0.2)
  other vias: -35.6,72
S$2316  (via drill 0.2)
  other vias: -34,68
S$2317  (via drill 0.2)
  other vias: -32.4,68
S$2318  (via drill 0.2)
  other vias: -30.8,68
S$2319  (via drill 0.2)
  other vias: -29.2,68
S$2320  (via drill 0.2)
  other vias: -27.6,68
S$2321  (via drill 0.2)
  other vias: -33.2,72
S$2322  (via drill 0.2)
  other vias: -31.6,72
S$2323  (via drill 0.2)
  other vias: -30,72
S$2324  (via drill 0.2)
  other vias: -28.4,72
S$2325  (via drill 0.2)
  other vias: -26.8,72
S$2326  (via drill 0.2)
  other vias: -26,68
S$2327  (via drill 0.2)
  other vias: -0.4,76
S$2328  (via drill 0.2)
  other vias: -2,76
S$2329  (via drill 0.2)
  other vias: -3.6,76
S$2330  (via drill 0.2)
  other vias: -5.2,76
S$2331  (via drill 0.2)
  other vias: -6.8,76
S$2332  (via drill 0.2)
  other vias: -8.4,76
S$2333  (via drill 0.2)
  other vias: -10,76
S$2334  (via drill 0.2)
  other vias: -11.6,76
S$2335  (via drill 0.2)
  other vias: -13.2,76
S$2336  (via drill 0.2)
  other vias: -14.8,76
S$2337  (via drill 0.2)
  other vias: -16.4,76
S$2338  (via drill 0.2)
  other vias: -1.2,72
S$2339  (via drill 0.2)
  other vias: -2.8,72
S$2340  (via drill 0.2)
  other vias: -4.4,72
S$2341  (via drill 0.2)
  other vias: -6,72
S$2342  (via drill 0.2)
  other vias: -7.6,72
S$2343  (via drill 0.2)
  other vias: -9.2,72
S$2344  (via drill 0.2)
  other vias: -10.8,72
S$2345  (via drill 0.2)
  other vias: -12.4,72
S$2346  (via drill 0.2)
  other vias: -14,72
S$2347  (via drill 0.2)
  other vias: -15.6,72
S$2348  (via drill 0.2)
  other vias: -17.2,68
S$2349  (via drill 0.2)
  other vias: -18.8,68
S$2350  (via drill 0.2)
  other vias: -20.4,68
S$2351  (via drill 0.2)
  other vias: -22,68
S$2352  (via drill 0.2)
  other vias: -23.6,68
S$2353  (via drill 0.2)
  other vias: -18,72
S$2354  (via drill 0.2)
  other vias: -19.6,72
S$2355  (via drill 0.2)
  other vias: -21.2,72
S$2356  (via drill 0.2)
  other vias: -22.8,72
S$2357  (via drill 0.2)
  other vias: -24.4,72
S$2358  (via drill 0.2)
  other vias: -25.2,68
S$2359  (via drill 0.2)
  other vias: 0.4,72
S$2360  (via drill 0.2)
  other vias: 2,72
S$2361  (via drill 0.2)
  other vias: 3.6,72
S$2362  (via drill 0.2)
  other vias: 5.2,72
S$2363  (via drill 0.2)
  other vias: 6.8,72
S$2364  (via drill 0.2)
  other vias: 8.4,72
S$2365  (via drill 0.2)
  other vias: 10,72
S$2366  (via drill 0.2)
  other vias: 11.6,72
S$2367  (via drill 0.2)
  other vias: 13.2,72
S$2368  (via drill 0.2)
  other vias: 14.8,72
S$2369  (via drill 0.2)
  other vias: 16.4,68
S$2370  (via drill 0.2)
  other vias: 1.2,68