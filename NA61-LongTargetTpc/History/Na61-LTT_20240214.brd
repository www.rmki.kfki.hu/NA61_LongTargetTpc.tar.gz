# EAGLE board Na61-LTT_20240214 (EAGLE 9.6.2), part 5 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$4573  (via drill 0.2) (continued)
  other vias: 82,154.9
S$4574  (via drill 0.2)
  other vias: 81.2,150.9
S$4575  (via drill 0.2)
  other vias: 80.4,154.9
S$4576  (via drill 0.2)
  other vias: 79.6,150.9
S$4577  (via drill 0.2)
  other vias: 78.8,154.9
S$4578  (via drill 0.2)
  other vias: 78,150.9
S$4579
  Bottom 0.152: -0.8,155.9 0.2,154.9
S$4580
  Bottom 0.152: 0.2,154.9 1.2,154.9
S$4581
  Bottom 0.152: 1.2,155.9 1.8,155.9
S$4582
  Bottom 0.152: 1.8,155.9 2.8,154.9
S$4583
  Bottom 0.152: 3.2,155.9 3.4,155.9
S$4584
  Bottom 0.152: 3.4,155.9 4.4,154.9
S$4585
  Bottom 0.152: 5.2,155.9 6,155.1
S$4586
  Bottom 0.152: 6,155.1 6,154.9
S$4587
  Bottom 0.152: 7.2,155.9 7.6,155.5
S$4588
  Bottom 0.152: 7.6,155.5 7.6,154.9
S$4589
  Bottom 0.152: 9.2,155.9 9.2,154.9
S$4590
  Bottom 0.152: 11.2,155.9 10.8,155.5
S$4591
  Bottom 0.152: 10.8,155.5 10.8,154.9
S$4592
  Bottom 0.152: 13.2,155.9 12.4,155.1
S$4593
  Bottom 0.152: 12.4,155.1 12.4,154.9
S$4594
  Bottom 0.152: 15.2,155.9 15,155.9
S$4595
  Bottom 0.152: 15,155.9 14,154.9
S$4596
  Bottom 0.152: 17.2,155.9 16.6,155.9
S$4597
  Bottom 0.152: 16.6,155.9 15.6,154.9
S$4598
  Bottom 0.152: 19.2,155.9 18.2,154.9
S$4599
  Bottom 0.152: 18.2,154.9 17.2,154.9
S$4600
  Bottom 0.152: 0.2,151.9 1.2,150.9
S$4601
  Bottom 0.152: 1.2,150.9 2,150.9
S$4602
  Bottom 0.152: 2.2,151.9 3.2,150.9
S$4603
  Bottom 0.152: 3.2,150.9 3.6,150.9
S$4604
  Bottom 0.152: 4.2,151.9 5.2,150.9
S$4605
  Bottom 0.152: 6.2,151.9 6.8,151.3
S$4606
  Bottom 0.152: 6.8,151.3 6.8,150.9
S$4607
  Bottom 0.152: 8.2,151.9 8.4,151.7
S$4608
  Bottom 0.152: 8.4,151.7 8.4,150.9
S$4609
  Bottom 0.152: 10.2,151.9 10,151.7
S$4610
  Bottom 0.152: 10,151.7 10,150.9
S$4611
  Bottom 0.152: 12.2,151.9 11.6,151.3
S$4612
  Bottom 0.152: 11.6,151.3 11.6,150.9
S$4613
  Bottom 0.152: 14.2,151.9 13.2,150.9
S$4614
  Bottom 0.152: 16.2,151.9 15.2,150.9
S$4615
  Bottom 0.152: 15.2,150.9 14.8,150.9
S$4616
  Bottom 0.152: 18.2,151.9 17.2,150.9
S$4617
  Bottom 0.152: 17.2,150.9 16.4,150.9
S$4618
  Bottom 0.152: 15.4,145.9 16.4,146.9
S$4619
  Bottom 0.152: 16.4,146.9 18,146.9
S$4620
  Bottom 0.152: 17.4,145.9 18.2,145.9
S$4621
  Bottom 0.152: 18.2,145.9 19.2,146.9
S$4622
  Bottom 0.152: 19.2,146.9 19.6,146.9
S$4623
  Bottom 0.152: 19.4,145.9 20.2,145.9
S$4624
  Bottom 0.152: 20.2,145.9 21.2,146.9
S$4625
  Bottom 0.152: 21.4,145.9 21.8,145.9
S$4626
  Bottom 0.152: 21.8,145.9 22.8,146.9
S$4627
  Bottom 0.152: 23.4,145.9 24.4,146.9
S$4628
  Bottom 0.152: 25.4,145.9 26,146.5
S$4629
  Bottom 0.152: 26,146.5 26,146.9
S$4630
  Bottom 0.152: 16.4,149.9 17,149.9
S$4631
  Bottom 0.152: 17,149.9 18,150.9
S$4632
  Bottom 0.152: 18,150.9 18.8,150.9
S$4633
  Bottom 0.152: 18.4,149.9 19,149.9
S$4634
  Bottom 0.152: 19,149.9 20,150.9
S$4635
  Bottom 0.152: 20,150.9 20.4,150.9
S$4636
  Bottom 0.152: 20.4,149.9 21,149.9
S$4637
  Bottom 0.152: 21,149.9 22,150.9
S$4638
  Bottom 0.152: 22.4,149.9 22.6,149.9
S$4639
  Bottom 0.152: 22.6,149.9 23.6,150.9
S$4640
  Bottom 0.152: 24.4,149.9 25.2,150.7
S$4641
  Bottom 0.152: 25.2,150.7 25.2,150.9
S$4642
  Bottom 0.152: 53.6,155.9 52.6,154.9
S$4643
  Bottom 0.152: 52.6,154.9 51.6,154.9
S$4644
  Bottom 0.152: 51.6,155.9 51,155.9
S$4645
  Bottom 0.152: 51,155.9 50,154.9
S$4646
  Bottom 0.152: 49.6,155.9 49.4,155.9
S$4647
  Bottom 0.152: 49.4,155.9 48.4,154.9
S$4648
  Bottom 0.152: 47.6,155.9 46.8,155.1
S$4649
  Bottom 0.152: 46.8,155.1 46.8,154.9
S$4650
  Bottom 0.152: 45.6,155.9 45.2,155.5
S$4651
  Bottom 0.152: 45.2,155.5 45.2,154.9
S$4652
  Bottom 0.152: 43.6,155.9 43.6,154.9
S$4653
  Bottom 0.152: 41.6,155.9 42,155.5
S$4654
  Bottom 0.152: 42,155.5 42,154.9
S$4655
  Bottom 0.152: 39.6,155.9 40.4,155.1
S$4656
  Bottom 0.152: 40.4,155.1 40.4,154.9
S$4657
  Bottom 0.152: 37.6,155.9 37.8,155.9
S$4658
  Bottom 0.152: 37.8,155.9 38.8,154.9
S$4659
  Bottom 0.152: 35.6,155.9 36.2,155.9
S$4660
  Bottom 0.152: 36.2,155.9 37.2,154.9
S$4661
  Bottom 0.152: 33.6,155.9 34.6,154.9
S$4662
  Bottom 0.152: 34.6,154.9 35.6,154.9
S$4663
  Bottom 0.152: 52.6,151.9 51.6,150.9
S$4664
  Bottom 0.152: 51.6,150.9 50.8,150.9
S$4665
  Bottom 0.152: 50.6,151.9 49.6,150.9
S$4666
  Bottom 0.152: 49.6,150.9 49.2,150.9
S$4667
  Bottom 0.152: 48.6,151.9 47.6,150.9
S$4668
  Bottom 0.152: 46.6,151.9 46,151.3
S$4669
  Bottom 0.152: 46,151.3 46,150.9
S$4670
  Bottom 0.152: 44.6,151.9 44.4,151.7
S$4671
  Bottom 0.152: 44.4,151.7 44.4,150.9
S$4672
  Bottom 0.152: 42.6,151.9 42.8,151.7
S$4673
  Bottom 0.152: 42.8,151.7 42.8,150.9
S$4674
  Bottom 0.152: 40.6,151.9 41.2,151.3
S$4675
  Bottom 0.152: 41.2,151.3 41.2,150.9
S$4676
  Bottom 0.152: 38.6,151.9 39.6,150.9
S$4677
  Bottom 0.152: 36.6,151.9 37.6,150.9
S$4678
  Bottom 0.152: 37.6,150.9 38,150.9
S$4679
  Bottom 0.152: 34.6,151.9 35.6,150.9
S$4680
  Bottom 0.152: 35.6,150.9 36.4,150.9
S$4681
  Bottom 0.152: 37.4,145.9 36.4,146.9
S$4682
  Bottom 0.152: 36.4,146.9 34.8,146.9
S$4683
  Bottom 0.152: 35.4,145.9 34.6,145.9
S$4684
  Bottom 0.152: 34.6,145.9 33.6,146.9
S$4685
  Bottom 0.152: 33.6,146.9 33.2,146.9
S$4686
  Bottom 0.152: 33.4,145.9 32.6,145.9
S$4687
  Bottom 0.152: 32.6,145.9 31.6,146.9
S$4688
  Bottom 0.152: 31.4,145.9 31,145.9
S$4689
  Bottom 0.152: 31,145.9 30,146.9
S$4690
  Bottom 0.152: 29.4,145.9 28.4,146.9
S$4691
  Bottom 0.152: 27.4,145.9 26.8,146.5
S$4692
  Bottom 0.152: 26.8,146.5 26.8,146.9
S$4693
  Bottom 0.152: 36.4,149.9 35.8,149.9
S$4694
  Bottom 0.152: 35.8,149.9 34.8,150.9
S$4695
  Bottom 0.152: 34.8,150.9 34,150.9
S$4696
  Bottom 0.152: 34.4,149.9 33.8,149.9
S$4697
  Bottom 0.152: 33.8,149.9 32.8,150.9
S$4698
  Bottom 0.152: 32.8,150.9 32.4,150.9
S$4699
  Bottom 0.152: 32.4,149.9 31.8,149.9
S$4700
  Bottom 0.152: 31.8,149.9 30.8,150.9
S$4701
  Bottom 0.152: 30.4,149.9 30.2,149.9
S$4702
  Bottom 0.152: 30.2,149.9 29.2,150.9
S$4703
  Bottom 0.152: 28.4,149.9 27.6,150.7
S$4704
  Bottom 0.152: 27.6,150.7 27.6,150.9
S$4705
  Bottom 0.152: 52.4,149.9 53,149.9
S$4706
  Bottom 0.152: 53,149.9 54,150.9
S$4707
  Bottom 0.152: 54.4,149.9 54.6,149.9
S$4708
  Bottom 0.152: 54.6,149.9 55.6,150.9
S$4709
  Bottom 0.152: 56.4,149.9 57.2,150.7
S$4710
  Bottom 0.152: 57.2,150.7 57.2,150.9
S$4711
  Bottom 0.152: 58.4,149.9 58.8,150.3
S$4712
  Bottom 0.152: 58.8,150.3 58.8,150.9
S$4713
  Bottom 0.152: 60.4,149.9 60.4,150.9
S$4714
  Bottom 0.152: 50.4,149.9 51.4,149.9
S$4715
  Bottom 0.152: 51.4,149.9 52.4,150.9
S$4716
  Bottom 0.152: 51.4,145.9 52.4,146.9
S$4717
  Bottom 0.152: 52.4,146.9 53.2,146.9
S$4718
  Bottom 0.152: 53.4,145.9 53.8,145.9
S$4719
  Bottom 0.152: 53.8,145.9 54.8,146.9
S$4720
  Bottom 0.152: 55.4,145.9 56.4,146.9
S$4721
  Bottom 0.152: 57.4,145.9 58,146.5
S$4722
  Bottom 0.152: 58,146.5 58,146.9
S$4723
  Bottom 0.152: 59.4,145.9 59.6,146.1
S$4724
  Bottom 0.152: 59.6,146.1 59.6,146.9
S$4725
  Bottom 0.152: 61.4,145.9 61.2,146.1
S$4726
  Bottom 0.152: 61.2,146.1 61.2,146.9
S$4727
  Bottom 0.152: 63.4,145.9 62.8,146.5
S$4728
  Bottom 0.152: 62.8,146.5 62.8,146.9
S$4729
  Bottom 0.152: 65.4,145.9 64.4,146.9
S$4730
  Bottom 0.152: 67.4,145.9 67,145.9
S$4731
  Bottom 0.152: 67,145.9 66,146.9
S$4732
  Bottom 0.152: 69.4,145.9 68.6,145.9
S$4733
  Bottom 0.152: 68.6,145.9 67.6,146.9
S$4734
  Bottom 0.152: 62.4,149.9 62,150.3
S$4735
  Bottom 0.152: 62,150.3 62,150.9
S$4736
  Bottom 0.152: 64.4,149.9 63.6,150.7
S$4737
  Bottom 0.152: 63.6,150.7 63.6,150.9
S$4738
  Bottom 0.152: 66.4,149.9 66.2,149.9
S$4739
  Bottom 0.152: 66.2,149.9 65.2,150.9
S$4740
  Bottom 0.152: 68.4,149.9 67.8,149.9
S$4741
  Bottom 0.152: 67.8,149.9 66.8,150.9
S$4742
  Bottom 0.152: 70.4,147.9 69.4,146.9
S$4743
  Bottom 0.152: 69.4,146.9 68.4,146.9
S$4744
  Bottom 0.152: 68.6,151.9 69.2,151.9
S$4745
  Bottom 0.152: 69.2,151.9 70.2,150.9
S$4746
  Bottom 0.152: 70.2,150.9 70.8,150.9
S$4747
  Bottom 0.152: 70.6,151.9 71.6,150.9
S$4748
  Bottom 0.152: 71.6,150.9 72.4,150.9
S$4749
  Bottom 0.152: 72.6,151.9 73.6,150.9
S$4750
  Bottom 0.152: 73.6,150.9 74,150.9
S$4751
  Bottom 0.152: 74.6,151.9 75.6,150.9
S$4752
  Bottom 0.152: 76.6,151.9 77.2,151.3
S$4753
  Bottom 0.152: 77.2,151.3 77.2,150.9
S$4754
  Bottom 0.152: 67.6,155.9 68.6,154.9
S$4755
  Bottom 0.152: 68.6,154.9 70,154.9
S$4756
  Bottom 0.152: 69.6,155.9 70,155.9
S$4757
  Bottom 0.152: 70,155.9 71,154.9
S$4758
  Bottom 0.152: 71,154.9 71.6,154.9
S$4759
  Bottom 0.152: 71.6,155.9 72.2,155.9
S$4760
  Bottom 0.152: 72.2,155.9 73.2,154.9
S$4761
  Bottom 0.152: 73.6,155.9 73.8,155.9
S$4762
  Bottom 0.152: 73.8,155.9 74.8,154.9
S$4763
  Bottom 0.152: 75.6,155.9 76.4,155.1
S$4764
  Bottom 0.152: 76.4,155.1 76.4,154.9
S$4765
  Bottom 0.152: 69.2,150.9 68,150.9
S$4766
  Bottom 0.152: 68,150.9 67,151.9
S$4767
  Bottom 0.152: 67,151.9 66.6,151.9
S$4768
  Bottom 0.152: 102.8,149.9 102.2,149.9
S$4769
  Bottom 0.152: 102.2,149.9 101.2,150.9
S$4770
  Bottom 0.152: 100.8,149.9 100.6,149.9
S$4771
  Bottom 0.152: 100.6,149.9 99.6,150.9
S$4772
  Bottom 0.152: 98.8,149.9 98,150.7
S$4773
  Bottom 0.152: 98,150.7 98,150.9
S$4774
  Bottom 0.152: 96.8,149.9 96.4,150.3
S$4775
  Bottom 0.152: 96.4,150.3 96.4,150.9
S$4776
  Bottom 0.152: 94.8,149.9 94.8,150.9
S$4777
  Bottom 0.152: 104.8,149.9 103.8,149.9
S$4778
  Bottom 0.152: 103.8,149.9 102.8,150.9
S$4779
  Bottom 0.152: 103.8,145.9 102.8,146.9
S$4780
  Bottom 0.152: 102.8,146.9 102,146.9
S$4781
  Bottom 0.152: 101.8,145.9 101.4,145.9
S$4782
  Bottom 0.152: 101.4,145.9 100.4,146.9
S$4783
  Bottom 0.152: 99.8,145.9 98.8,146.9
S$4784
  Bottom 0.152: 97.8,145.9 97.2,146.5
S$4785
  Bottom 0.152: 97.2,146.5 97.2,146.9
S$4786
  Bottom 0.152: 95.8,145.9 95.6,146.1
S$4787
  Bottom 0.152: 95.6,146.1 95.6,146.9
S$4788
  Bottom 0.152: 93.8,145.9 94,146.1
S$4789
  Bottom 0.152: 94,146.1 94,146.9
S$4790
  Bottom 0.152: 91.8,145.9 92.4,146.5
S$4791
  Bottom 0.152: 92.4,146.5 92.4,146.9
S$4792
  Bottom 0.152: 89.8,145.9 90.8,146.9
S$4793
  Bottom 0.152: 87.8,145.9 88.2,145.9
S$4794
  Bottom 0.152: 88.2,145.9 89.2,146.9
S$4795
  Bottom 0.152: 85.8,145.9 86.6,145.9
S$4796
  Bottom 0.152: 86.6,145.9 87.6,146.9
S$4797
  Bottom 0.152: 92.8,149.9 93.2,150.3
S$4798
  Bottom 0.152: 93.2,150.3 93.2,150.9
S$4799
  Bottom 0.152: 90.8,149.9 91.6,150.7
S$4800
  Bottom 0.152: 91.6,150.7 91.6,150.9
S$4801
  Bottom 0.152: 88.8,149.9 89,149.9
S$4802
  Bottom 0.152: 89,149.9 90,150.9
S$4803
  Bottom 0.152: 86.8,149.9 87.4,149.9
S$4804
  Bottom 0.152: 87.4,149.9 88.4,150.9
S$4805
  Bottom 0.152: 84.8,147.9 85.8,146.9
S$4806
  Bottom 0.152: 85.8,146.9 86.8,146.9
S$4807
  Bottom 0.152: 86.6,151.9 86,151.9
S$4808
  Bottom 0.152: 86,151.9 85,150.9
S$4809
  Bottom 0.152: 85,150.9 84.4,150.9
S$4810
  Bottom 0.152: 84.6,151.9 83.6,150.9
S$4811
  Bottom 0.152: 83.6,150.9 82.8,150.9
S$4812
  Bottom 0.152: 82.6,151.9 81.6,150.9
S$4813
  Bottom 0.152: 81.6,150.9 81.2,150.9
S$4814
  Bottom 0.152: 80.6,151.9 79.6,150.9
S$4815
  Bottom 0.152: 78.6,151.9 78,151.3
S$4816
  Bottom 0.152: 78,151.3 78,150.9
S$4817
  Bottom 0.152: 87.6,155.9 86.6,154.9
S$4818
  Bottom 0.152: 86.6,154.9 85.2,154.9
S$4819
  Bottom 0.152: 85.6,155.9 85.2,155.9
S$4820
  Bottom 0.152: 85.2,155.9 84.2,154.9
S$4821
  Bottom 0.152: 84.2,154.9 83.6,154.9
S$4822
  Bottom 0.152: 83.6,155.9 83,155.9
S$4823
  Bottom 0.152: 83,155.9 82,154.9
S$4824
  Bottom 0.152: 81.6,155.9 81.4,155.9
S$4825
  Bottom 0.152: 81.4,155.9 80.4,154.9
S$4826
  Bottom 0.152: 79.6,155.9 78.8,155.1
S$4827
  Bottom 0.152: 78.8,155.1 78.8,154.9
S$4828
  Bottom 0.152: 86,150.9 87.2,150.9
S$4829
  Bottom 0.152: 87.2,150.9 88.2,151.9
S$4830
  Bottom 0.152: 88.2,151.9 88.6,151.9
S$4831  (2 unrouted)
  Top 0.813: 117,155.4 117,146.4
  Top 1.8: 118,152.4 116,152.4 | 118,155.4 117,155.4 116,155.4 | 118,149.4 116,149.4 | 118,146.4 117,146.4 116,146.4
S$4832
  Top 1.778: -52.08,147.72 -52.08,149.25
S$4833
  Top 1.778: -52.08,152.55 -52.08,154.08
S$4834
  Top 1.778: -47,147.72 -47,149.25
S$4835
  Top 1.778: -47,152.55 -47,154.08
S$4836
  Top 1.778: -41.92,147.72 -41.92,149.25
S$4837
  Top 1.778: -41.92,152.55 -41.92,154.08
S$4838
  Top 1.778: 145.92,147.72 145.92,149.25
S$4839
  Top 1.778: 145.92,152.55 145.92,154.08
S$4840
  Top 1.778: 151,147.72 151,149.25
S$4841
  Top 1.778: 151,152.55 151,154.08
S$4842
  Top 1.778: 156.08,147.72 156.08,149.25
S$4843
  Top 1.778: 156.08,152.55 156.08,154.08
S$4844  (via drill 0.2)
  other vias: 26.4,157.3
S$4845  (via drill 0.2)
  other vias: 43.4,144.5
S$4846  (via drill 0.2)
  other vias: 60.6,157.3
S$4847  (via drill 0.2)
  other vias: 77.6,144.5
S$4848  (via drill 0.2)
  other vias: 93.6,157.3
S$4849  (via drill 0.2)
  other vias: 104.8,157.3
S$4850  (via drill 0.2)
  other vias: 10.4,144.5
S$4851  (via drill 0.2)
  other vias: -0.8,144.5
S$4852
  Bottom 0.8: 61.4,163.8 61.4,162
S$4853
  Bottom 0.8: 63.4,163.8 63.4,162
S$4854
  Bottom 0.8: 60.4,166 60.4,167.8
S$4855
  Bottom 0.8: 62.4,166 62.4,167.8
S$4856
  Bottom 0.8: 57.4,163.8 57.4,162
S$4857
  Bottom 0.8: 59.4,163.8 59.4,162
S$4858
  Bottom 0.8: 58.4,166 58.4,167.8
S$4859
  Bottom 0.8: 56.4,166 56.4,167.8
S$4860
  Bottom 0.8: 55.4,163.8 55.4,162
S$4861
  Bottom 0.8: 53.4,163.8 53.4,162
S$4862
  Bottom 0.8: 54.4,166 54.4,167.8
S$4863
  Bottom 0.8: 52.4,166 52.4,167.8
S$4864
  Bottom 0.8: 51.4,163.8 51.4,162
S$4865
  Bottom 0.8: 49.4,163.8 49.4,162
S$4866
  Bottom 0.8: 50.4,166 50.4,167.8
S$4867
  Bottom 0.8: 69.4,163.8 69.4,162
S$4868
  Bottom 0.8: 71.4,163.8 71.4,162
S$4869
  Bottom 0.8: 68.4,166 68.4,167.8
S$4870
  Bottom 0.8: 70.4,166 70.4,167.8
S$4871
  Bottom 0.8: 65.4,163.8 65.4,162
S$4872
  Bottom 0.8: 67.4,163.8 67.4,162
S$4873
  Bottom 0.8: 64.4,166 64.4,167.8
S$4874
  Bottom 0.8: 66.4,166 66.4,167.8
S$4875
  Bottom 0.8: 44.6,171.8 44.6,170
S$4876
  Bottom 0.8: 46.6,171.8 46.6,170
S$4877
  Bottom 0.8: 43.6,174 43.6,175.8
S$4878
  Bottom 0.8: 45.6,174 45.6,175.8
S$4879
  Bottom 0.8: 40.6,171.8 40.6,170
S$4880
  Bottom 0.8: 42.6,171.8 42.6,170
S$4881
  Bottom 0.8: 41.6,174 41.6,175.8
S$4882
  Bottom 0.8: 39.6,174 39.6,175.8
S$4883
  Bottom 0.8: 38.6,171.8 38.6,170
S$4884
  Bottom 0.8: 36.6,171.8 36.6,170
S$4885
  Bottom 0.8: 37.6,174 37.6,175.8
S$4886
  Bottom 0.8: 35.6,174 35.6,175.8
S$4887
  Bottom 0.8: 34.6,171.8 34.6,170
S$4888
  Bottom 0.8: 32.6,171.8 32.6,170
S$4889
  Bottom 0.8: 33.6,174 33.6,175.8
S$4890
  Bottom 0.8: 52.6,171.8 52.6,170
S$4891
  Bottom 0.8: 54.6,171.8 54.6,170
S$4892
  Bottom 0.8: 51.6,174 51.6,175.8
S$4893
  Bottom 0.8: 53.6,174 53.6,175.8
S$4894
  Bottom 0.8: 48.6,171.8 48.6,170
S$4895
  Bottom 0.8: 50.6,171.8 50.6,170
S$4896
  Bottom 0.8: 47.6,174 47.6,175.8
S$4897
  Bottom 0.8: 49.6,174 49.6,175.8
S$4898
  Bottom 0.8: 27.4,163.8 27.4,162
S$4899
  Bottom 0.8: 29.4,163.8 29.4,162
S$4900
  Bottom 0.8: 26.4,166 26.4,167.8
S$4901
  Bottom 0.8: 28.4,166 28.4,167.8
S$4902
  Bottom 0.8: 23.4,163.8 23.4,162
S$4903
  Bottom 0.8: 25.4,163.8 25.4,162
S$4904
  Bottom 0.8: 24.4,166 24.4,167.8
S$4905
  Bottom 0.8: 22.4,166 22.4,167.8
S$4906
  Bottom 0.8: 21.4,163.8 21.4,162
S$4907
  Bottom 0.8: 19.4,163.8 19.4,162
S$4908
  Bottom 0.8: 20.4,166 20.4,167.8
S$4909
  Bottom 0.8: 18.4,166 18.4,167.8
S$4910
  Bottom 0.8: 17.4,163.8 17.4,162
S$4911
  Bottom 0.8: 15.4,163.8 15.4,162
S$4912
  Bottom 0.8: 16.4,166 16.4,167.8
S$4913
  Bottom 0.8: 35.4,163.8 35.4,162
S$4914
  Bottom 0.8: 37.4,163.8 37.4,162
S$4915
  Bottom 0.8: 34.4,166 34.4,167.8
S$4916
  Bottom 0.8: 36.4,166 36.4,167.8
S$4917
  Bottom 0.8: 31.4,163.8 31.4,162
S$4918
  Bottom 0.8: 33.4,163.8 33.4,162
S$4919
  Bottom 0.8: 30.4,166 30.4,167.8
S$4920
  Bottom 0.8: 32.4,166 32.4,167.8
S$4921
  Bottom 0.8: 78.6,171.8 78.6,170
S$4922
  Bottom 0.8: 80.6,171.8 80.6,170
S$4923
  Bottom 0.8: 77.6,174 77.6,175.8
S$4924
  Bottom 0.8: 79.6,174 79.6,175.8
S$4925
  Bottom 0.8: 74.6,171.8 74.6,170
S$4926
  Bottom 0.8: 76.6,171.8 76.6,170
S$4927
  Bottom 0.8: 75.6,174 75.6,175.8
S$4928
  Bottom 0.8: 73.6,174 73.6,175.8
S$4929
  Bottom 0.8: 72.6,171.8 72.6,170
S$4930
  Bottom 0.8: 70.6,171.8 70.6,170
S$4931
  Bottom 0.8: 71.6,174 71.6,175.8
S$4932
  Bottom 0.8: 69.6,174 69.6,175.8
S$4933
  Bottom 0.8: 68.6,171.8 68.6,170
S$4934
  Bottom 0.8: 66.6,171.8 66.6,170
S$4935
  Bottom 0.8: 67.6,174 67.6,175.8
S$4936
  Bottom 0.8: 86.6,171.8 86.6,170
S$4937
  Bottom 0.8: 88.6,171.8 88.6,170
S$4938
  Bottom 0.8: 85.6,174 85.6,175.8
S$4939
  Bottom 0.8: 87.6,174 87.6,175.8
S$4940
  Bottom 0.8: 82.6,171.8 82.6,170
S$4941
  Bottom 0.8: 84.6,171.8 84.6,170
S$4942
  Bottom 0.8: 81.6,174 81.6,175.8
S$4943
  Bottom 0.8: 83.6,174 83.6,175.8
S$4944
  Bottom 0.8: 10.2,171.8 10.2,170
S$4945
  Bottom 0.8: 12.2,171.8 12.2,170
S$4946
  Bottom 0.8: 9.2,174 9.2,175.8
S$4947
  Bottom 0.8: 11.2,174 11.2,175.8
S$4948
  Bottom 0.8: 6.2,171.8 6.2,170
S$4949
  Bottom 0.8: 8.2,171.8 8.2,170
S$4950
  Bottom 0.8: 7.2,174 7.2,175.8
S$4951
  Bottom 0.8: 5.2,174 5.2,175.8
S$4952
  Bottom 0.8: 4.2,171.8 4.2,170
S$4953
  Bottom 0.8: 2.2,171.8 2.2,170
S$4954
  Bottom 0.8: 3.2,174 3.2,175.8
S$4955
  Bottom 0.8: 1.2,174 1.2,175.8
S$4956
  Bottom 0.8: 0.2,171.8 0.2,170
S$4957
  Bottom 0.8: -1.8,171.8 -1.8,170
S$4958
  Bottom 0.8: -0.8,174 -0.8,175.8
S$4959
  Bottom 0.8: 18.2,171.8 18.2,170
S$4960
  Bottom 0.8: 20.2,171.8 20.2,170
S$4961
  Bottom 0.8: 17.2,174 17.2,175.8
S$4962
  Bottom 0.8: 19.2,174 19.2,175.8
S$4963
  Bottom 0.8: 14.2,171.8 14.2,170
S$4964
  Bottom 0.8: 16.2,171.8 16.2,170
S$4965
  Bottom 0.8: 13.2,174 13.2,175.8
S$4966
  Bottom 0.8: 15.2,174 15.2,175.8
S$4967
  Bottom 0.8: 95.8,163.8 95.8,162
S$4968
  Bottom 0.8: 97.8,163.8 97.8,162
S$4969
  Bottom 0.8: 94.8,166 94.8,167.8
S$4970
  Bottom 0.8: 96.8,166 96.8,167.8
S$4971
  Bottom 0.8: 91.8,163.8 91.8,162
S$4972
  Bottom 0.8: 93.8,163.8 93.8,162
S$4973
  Bottom 0.8: 92.8,166 92.8,167.8
S$4974
  Bottom 0.8: 90.8,166 90.8,167.8
S$4975
  Bottom 0.8: 89.8,163.8 89.8,162
S$4976
  Bottom 0.8: 87.8,163.8 87.8,162
S$4977
  Bottom 0.8: 88.8,166 88.8,167.8
S$4978
  Bottom 0.8: 86.8,166 86.8,167.8
S$4979
  Bottom 0.8: 85.8,163.8 85.8,162
S$4980
  Bottom 0.8: 83.8,163.8 83.8,162
S$4981
  Bottom 0.8: 84.8,166 84.8,167.8
S$4982
  Bottom 0.8: 103.8,163.8 103.8,162
S$4983
  Bottom 0.8: 105.8,163.8 105.8,162
S$4984
  Bottom 0.8: 102.8,166 102.8,167.8
S$4985
  Bottom 0.8: 104.8,166 104.8,167.8
S$4986
  Bottom 0.8: 99.8,163.8 99.8,162
S$4987
  Bottom 0.8: 101.8,163.8 101.8,162
S$4988
  Bottom 0.8: 98.8,166 98.8,167.8
S$4989
  Bottom 0.8: 100.8,166 100.8,167.8
S$4990  (via drill 0.2)
  other vias: 1.2,172.9
S$4991  (via drill 0.2)
  other vias: 2.8,172.9
S$4992  (via drill 0.2)
  other vias: 4.4,172.9
S$4993  (via drill 0.2)
  other vias: 6,172.9
S$4994  (via drill 0.2)
  other vias: 7.6,172.9
S$4995  (via drill 0.2)
  other vias: 9.2,172.9
S$4996  (via drill 0.2)
  other vias: 10.8,172.9
S$4997  (via drill 0.2)
  other vias: 12.4,172.9
S$4998  (via drill 0.2)
  other vias: 14,172.9
S$4999  (via drill 0.2)
  other vias: 15.6,172.9
S$5000  (via drill 0.2)
  other vias: 17.2,172.9
S$5001  (via drill 0.2)
  other vias: 2,168.9
S$5002  (via drill 0.2)
  other vias: 3.6,168.9
S$5003  (via drill 0.2)
  other vias: 5.2,168.9
S$5004  (via drill 0.2)
  other vias: 6.8,168.9
S$5005  (via drill 0.2)
  other vias: 8.4,168.9
S$5006  (via drill 0.2)
  other vias: 10,168.9
S$5007  (via drill 0.2)
  other vias: 11.6,168.9
S$5008  (via drill 0.2)
  other vias: 13.2,168.9
S$5009  (via drill 0.2)
  other vias: 14.8,168.9
S$5010  (via drill 0.2)
  other vias: 16.4,168.9
S$5011  (via drill 0.2)
  other vias: 18,164.9
S$5012  (via drill 0.2)
  other vias: 19.6,164.9
S$5013  (via drill 0.2)
  other vias: 21.2,164.9
S$5014  (via drill 0.2)
  other vias: 22.8,164.9
S$5015  (via drill 0.2)
  other vias: 24.4,164.9
S$5016  (via drill 0.2)
  other vias: 18.8,168.9
S$5017  (via drill 0.2)
  other vias: 20.4,168.9
S$5018  (via drill 0.2)
  other vias: 22,168.9
S$5019  (via drill 0.2)
  other vias: 23.6,168.9
S$5020  (via drill 0.2)
  other vias: 25.2,168.9
S$5021  (via drill 0.2)
  other vias: 26,164.9
S$5022  (via drill 0.2)
  other vias: 51.6,172.9
S$5023  (via drill 0.2)
  other vias: 50,172.9
S$5024  (via drill 0.2)
  other vias: 48.4,172.9
S$5025  (via drill 0.2)
  other vias: 46.8,172.9
S$5026  (via drill 0.2)
  other vias: 45.2,172.9
S$5027  (via drill 0.2)
  other vias: 43.6,172.9
S$5028  (via drill 0.2)
  other vias: 42,172.9
S$5029  (via drill 0.2)
  other vias: 40.4,172.9
S$5030  (via drill 0.2)
  other vias: 38.8,172.9
S$5031  (via drill 0.2)
  other vias: 37.2,172.9
S$5032  (via drill 0.2)
  other vias: 35.6,172.9
S$5033  (via drill 0.2)
  other vias: 50.8,168.9
S$5034  (via drill 0.2)
  other vias: 49.2,168.9
S$5035  (via drill 0.2)
  other vias: 47.6,168.9
S$5036  (via drill 0.2)
  other vias: 46,168.9
S$5037  (via drill 0.2)
  other vias: 44.4,168.9
S$5038  (via drill 0.2)
  other vias: 42.8,168.9
S$5039  (via drill 0.2)
  other vias: 41.2,168.9
S$5040  (via drill 0.2)
  other vias: 39.6,168.9
S$5041  (via drill 0.2)
  other vias: 38,168.9
S$5042  (via drill 0.2)
  other vias: 36.4,168.9
S$5043  (via drill 0.2)
  other vias: 34.8,164.9
S$5044  (via drill 0.2)
  other vias: 33.2,164.9
S$5045  (via drill 0.2)
  other vias: 31.6,164.9
S$5046  (via drill 0.2)
  other vias: 30,164.9
S$5047  (via drill 0.2)
  other vias: 28.4,164.9
S$5048  (via drill 0.2)
  other vias: 34,168.9
S$5049  (via drill 0.2)
  other vias: 32.4,168.9
S$5050  (via drill 0.2)
  other vias: 30.8,168.9
S$5051  (via drill 0.2)
  other vias: 29.2,168.9
S$5052  (via drill 0.2)
  other vias: 27.6,168.9
S$5053  (via drill 0.2)
  other vias: 26.8,164.9
S$5054  (via drill 0.2)
  other vias: 52.4,168.9
S$5055  (via drill 0.2)
  other vias: 54,168.9
S$5056  (via drill 0.2)
  other vias: 55.6,168.9
S$5057  (via drill 0.2)
  other vias: 57.2,168.9
S$5058  (via drill 0.2)
  other vias: 58.8,168.9
S$5059  (via drill 0.2)
  other vias: 60.4,168.9
S$5060  (via drill 0.2)
  other vias: 62,168.9
S$5061  (via drill 0.2)
  other vias: 63.6,168.9
S$5062  (via drill 0.2)
  other vias: 65.2,168.9
S$5063  (via drill 0.2)
  other vias: 66.8,168.9
S$5064  (via drill 0.2)
  other vias: 68.4,164.9
S$5065  (via drill 0.2)
  other vias: 53.2,164.9
S$5066  (via drill 0.2)
  other vias: 54.8,164.9
S$5067  (via drill 0.2)
  other vias: 56.4,164.9
S$5068  (via drill 0.2)
  other vias: 58,164.9
S$5069  (via drill 0.2)
  other vias: 59.6,164.9
S$5070  (via drill 0.2)
  other vias: 61.2,164.9
S$5071  (via drill 0.2)
  other vias: 62.8,164.9
S$5072  (via drill 0.2)
  other vias: 64.4,164.9
S$5073  (via drill 0.2)
  other vias: 66,164.9
S$5074  (via drill 0.2)
  other vias: 67.6,164.9
S$5075  (via drill 0.2)
  other vias: 69.2,168.9
S$5076  (via drill 0.2)
  other vias: 70.8,168.9
S$5077  (via drill 0.2)
  other vias: 72.4,168.9
S$5078  (via drill 0.2)
  other vias: 70,172.9
S$5079  (via drill 0.2)
  other vias: 71.6,172.9
S$5080  (via drill 0.2)
  other vias: 73.2,172.9
S$5081  (via drill 0.2)
  other vias: 74,168.9
S$5082  (via drill 0.2)
  other vias: 74.8,172.9
S$5083  (via drill 0.2)
  other vias: 75.6,168.9
S$5084  (via drill 0.2)
  other vias: 76.4,172.9
S$5085  (via drill 0.2)
  other vias: 77.2,168.9
S$5086  (via drill 0.2)
  other vias: 102.8,168.9
S$5087  (via drill 0.2)
  other vias: 101.2,168.9
S$5088  (via drill 0.2)
  other vias: 99.6,168.9
S$5089  (via drill 0.2)
  other vias: 98,168.9
S$5090  (via drill 0.2)
  other vias: 96.4,168.9
S$5091  (via drill 0.2)
  other vias: 94.8,168.9
S$5092  (via drill 0.2)
  other vias: 93.2,168.9
S$5093  (via drill 0.2)
  other vias: 91.6,168.9
S$5094  (via drill 0.2)
  other vias: 90,168.9
S$5095  (via drill 0.2)
  other vias: 88.4,168.9
S$5096  (via drill 0.2)
  other vias: 86.8,164.9
S$5097  (via drill 0.2)
  other vias: 102,164.9
S$5098  (via drill 0.2)
  other vias: 100.4,164.9
S$5099  (via drill 0.2)
  other vias: 98.8,164.9
S$5100  (via drill 0.2)
  other vias: 97.2,164.9
S$5101  (via drill 0.2)
  other vias: 95.6,164.9
S$5102  (via drill 0.2)
  other vias: 94,164.9
S$5103  (via drill 0.2)
  other vias: 92.4,164.9
S$5104  (via drill 0.2)
  other vias: 90.8,164.9
S$5105  (via drill 0.2)
  other vias: 89.2,164.9
S$5106  (via drill 0.2)
  other vias: 87.6,164.9
S$5107  (via drill 0.2)
  other vias: 86,168.9
S$5108  (via drill 0.2)
  other vias: 84.4,168.9
S$5109  (via drill 0.2)
  other vias: 82.8,168.9
S$5110  (via drill 0.2)
  other vias: 85.2,172.9
S$5111  (via drill 0.2)
  other vias: 83.6,172.9
S$5112  (via drill 0.2)
  other vias: 82,172.9
S$5113  (via drill 0.2)
  other vias: 81.2,168.9
S$5114  (via drill 0.2)
  other vias: 80.4,172.9
S$5115  (via drill 0.2)
  other vias: 79.6,168.9
S$5116  (via drill 0.2)
  other vias: 78.8,172.9
S$5117  (via drill 0.2)
  other vias: 78,168.9
S$5118
  Bottom 0.152: -0.8,173.9 0.2,172.9
S$5119
  Bottom 0.152: 0.2,172.9 1.2,172.9
S$5120
  Bottom 0.152: 1.2,173.9 1.8,173.9
S$5121
  Bottom 0.152: 1.8,173.9 2.8,172.9
S$5122
  Bottom 0.152: 3.2,173.9 3.4,173.9
S$5123
  Bottom 0.152: 3.4,173.9 4.4,172.9
S$5124
  Bottom 0.152: 5.2,173.9 6,173.1
S$5125
  Bottom 0.152: 6,173.1 6,172.9
S$5126
  Bottom 0.152: 7.2,173.9 7.6,173.5
S$5127
  Bottom 0.152: 7.6,173.5 7.6,172.9
S$5128
  Bottom 0.152: 9.2,173.9 9.2,172.9
S$5129
  Bottom 0.152: 11.2,173.9 10.8,173.5
S$5130
  Bottom 0.152: 10.8,173.5 10.8,172.9
S$5131
  Bottom 0.152: 13.2,173.9 12.4,173.1
S$5132
  Bottom 0.152: 12.4,173.1 12.4,172.9
S$5133
  Bottom 0.152: 15.2,173.9 15,173.9
S$5134
  Bottom 0.152: 15,173.9 14,172.9
S$5135
  Bottom 0.152: 17.2,173.9 16.6,173.9
S$5136
  Bottom 0.152: 16.6,173.9 15.6,172.9
S$5137
  Bottom 0.152: 19.2,173.9 18.2,172.9
S$5138
  Bottom 0.152: 18.2,172.9 17.2,172.9
S$5139
  Bottom 0.152: 0.2,169.9 1.2,168.9
S$5140
  Bottom 0.152: 1.2,168.9 2,168.9
S$5141
  Bottom 0.152: 2.2,169.9 3.2,168.9
S$5142
  Bottom 0.152: 3.2,168.9 3.6,168.9
S$5143
  Bottom 0.152: 4.2,169.9 5.2,168.9
S$5144
  Bottom 0.152: 6.2,169.9 6.8,169.3
S$5145
  Bottom 0.152: 6.8,169.3 6.8,168.9
S$5146
  Bottom 0.152: 8.2,169.9 8.4,169.7
S$5147
  Bottom 0.152: 8.4,169.7 8.4,168.9
S$5148
  Bottom 0.152: 10.2,169.9 10,169.7
S$5149
  Bottom 0.152: 10,169.7 10,168.9
S$5150
  Bottom 0.152: 12.2,169.9 11.6,169.3
S$5151
  Bottom 0.152: 11.6,169.3 11.6,168.9
S$5152
  Bottom 0.152: 14.2,169.9 13.2,168.9
S$5153
  Bottom 0.152: 16.2,169.9 15.2,168.9
S$5154
  Bottom 0.152: 15.2,168.9 14.8,168.9
S$5155
  Bottom 0.152: 18.2,169.9 17.2,168.9
S$5156
  Bottom 0.152: 17.2,168.9 16.4,168.9
S$5157
  Bottom 0.152: 15.4,163.9 16.4,164.9
S$5158
  Bottom 0.152: 16.4,164.9 18,164.9
S$5159
  Bottom 0.152: 17.4,163.9 18.2,163.9
S$5160
  Bottom 0.152: 18.2,163.9 19.2,164.9
S$5161
  Bottom 0.152: 19.2,164.9 19.6,164.9
S$5162
  Bottom 0.152: 19.4,163.9 20.2,163.9
S$5163
  Bottom 0.152: 20.2,163.9 21.2,164.9
S$5164
  Bottom 0.152: 21.4,163.9 21.8,163.9
S$5165
  Bottom 0.152: 21.8,163.9 22.8,164.9
S$5166
  Bottom 0.152: 23.4,163.9 24.4,164.9
S$5167
  Bottom 0.152: 25.4,163.9 26,164.5
S$5168
  Bottom 0.152: 26,164.5 26,164.9
S$5169
  Bottom 0.152: 16.4,167.9 17,167.9
S$5170
  Bottom 0.152: 17,167.9 18,168.9
S$5171
  Bottom 0.152: 18,168.9 18.8,168.9
S$5172
  Bottom 0.152: 18.4,167.9 19,167.9
S$5173
  Bottom 0.152: 19,167.9 20,168.9
S$5174
  Bottom 0.152: 20,168.9 20.4,168.9
S$5175
  Bottom 0.152: 20.4,167.9 21,167.9
S$5176
  Bottom 0.152: 21,167.9 22,168.9
S$5177
  Bottom 0.152: 22.4,167.9 22.6,167.9
S$5178
  Bottom 0.152: 22.6,167.9 23.6,168.9
S$5179
  Bottom 0.152: 24.4,167.9 25.2,168.7
S$5180
  Bottom 0.152: 25.2,168.7 25.2,168.9
S$5181
  Bottom 0.152: 53.6,173.9 52.6,172.9
S$5182
  Bottom 0.152: 52.6,172.9 51.6,172.9
S$5183
  Bottom 0.152: 51.6,173.9 51,173.9
S$5184
  Bottom 0.152: 51,173.9 50,172.9
S$5185
  Bottom 0.152: 49.6,173.9 49.4,173.9
S$5186
  Bottom 0.152: 49.4,173.9 48.4,172.9
S$5187
  Bottom 0.152: 47.6,173.9 46.8,173.1
S$5188
  Bottom 0.152: 46.8,173.1 46.8,172.9
S$5189
  Bottom 0.152: 45.6,173.9 45.2,173.5
S$5190
  Bottom 0.152: 45.2,173.5 45.2,172.9
S$5191
  Bottom 0.152: 43.6,173.9 43.6,172.9
S$5192
  Bottom 0.152: 41.6,173.9 42,173.5
S$5193
  Bottom 0.152: 42,173.5 42,172.9
S$5194
  Bottom 0.152: 39.6,173.9 40.4,173.1
S$5195
  Bottom 0.152: 40.4,173.1 40.4,172.9
S$5196
  Bottom 0.152: 37.6,173.9 37.8,173.9
S$5197
  Bottom 0.152: 37.8,173.9 38.8,172.9
S$5198
  Bottom 0.152: 35.6,173.9 36.2,173.9
S$5199
  Bottom 0.152: 36.2,173.9 37.2,172.9
S$5200
  Bottom 0.152: 33.6,173.9 34.6,172.9
S$5201
  Bottom 0.152: 34.6,172.9 35.6,172.9
S$5202
  Bottom 0.152: 52.6,169.9 51.6,168.9
S$5203
  Bottom 0.152: 51.6,168.9 50.8,168.9
S$5204
  Bottom 0.152: 50.6,169.9 49.6,168.9
S$5205
  Bottom 0.152: 49.6,168.9 49.2,168.9
S$5206
  Bottom 0.152: 48.6,169.9 47.6,168.9
S$5207
  Bottom 0.152: 46.6,169.9 46,169.3
S$5208
  Bottom 0.152: 46,169.3 46,168.9
S$5209
  Bottom 0.152: 44.6,169.9 44.4,169.7
S$5210
  Bottom 0.152: 44.4,169.7 44.4,168.9
S$5211
  Bottom 0.152: 42.6,169.9 42.8,169.7
S$5212
  Bottom 0.152: 42.8,169.7 42.8,168.9
S$5213
  Bottom 0.152: 40.6,169.9 41.2,169.3
S$5214
  Bottom 0.152: 41.2,169.3 41.2,168.9
S$5215
  Bottom 0.152: 38.6,169.9 39.6,168.9
S$5216
  Bottom 0.152: 36.6,169.9 37.6,168.9
S$5217
  Bottom 0.152: 37.6,168.9 38,168.9
S$5218
  Bottom 0.152: 34.6,169.9 35.6,168.9
S$5219
  Bottom 0.152: 35.6,168.9 36.4,168.9
S$5220
  Bottom 0.152: 37.4,163.9 36.4,164.9
S$5221
  Bottom 0.152: 36.4,164.9 34.8,164.9
S$5222
  Bottom 0.152: 35.4,163.9 34.6,163.9
S$5223
  Bottom 0.152: 34.6,163.9 33.6,164.9
S$5224
  Bottom 0.152: 33.6,164.9 33.2,164.9
S$5225
  Bottom 0.152: 33.4,163.9 32.6,163.9
S$5226
  Bottom 0.152: 32.6,163.9 31.6,164.9
S$5227
  Bottom 0.152: 31.4,163.9 31,163.9
S$5228
  Bottom 0.152: 31,163.9 30,164.9
S$5229
  Bottom 0.152: 29.4,163.9 28.4,164.9
S$5230
  Bottom 0.152: 27.4,163.9 26.8,164.5
S$5231
  Bottom 0.152: 26.8,164.5 26.8,164.9
S$5232
  Bottom 0.152: 36.4,167.9 35.8,167.9
S$5233
  Bottom 0.152: 35.8,167.9 34.8,168.9
S$5234
  Bottom 0.152: 34.8,168.9 34,168.9
S$5235
  Bottom 0.152: 34.4,167.9 33.8,167.9
S$5236
  Bottom 0.152: 33.8,167.9 32.8,168.9
S$5237
  Bottom 0.152: 32.8,168.9 32.4,168.9
S$5238
  Bottom 0.152: 32.4,167.9 31.8,167.9
S$5239
  Bottom 0.152: 31.8,167.9 30.8,168.9
S$5240
  Bottom 0.152: 30.4,167.9 30.2,167.9
S$5241
  Bottom 0.152: 30.2,167.9 29.2,168.9
S$5242
  Bottom 0.152: 28.4,167.9 27.6,168.7
S$5243
  Bottom 0.152: 27.6,168.7 27.6,168.9
S$5244
  Bottom 0.152: 52.4,167.9 53,167.9
S$5245
  Bottom 0.152: 53,167.9 54,168.9
S$5246
  Bottom 0.152: 54.4,167.9 54.6,167.9
S$5247
  Bottom 0.152: 54.6,167.9 55.6,168.9
S$5248
  Bottom 0.152: 56.4,167.9 57.2,168.7
S$5249
  Bottom 0.152: 57.2,168.7 57.2,168.9
S$5250
  Bottom 0.152: 58.4,167.9 58.8,168.3
S$5251
  Bottom 0.152: 58.8,168.3 58.8,168.9
S$5252
  Bottom 0.152: 60.4,167.9 60.4,168.9
S$5253
  Bottom 0.152: 50.4,167.9 51.4,167.9
S$5254
  Bottom 0.152: 51.4,167.9 52.4,168.9
S$5255
  Bottom 0.152: 51.4,163.9 52.4,164.9
S$5256
  Bottom 0.152: 52.4,164.9 53.2,164.9
S$5257
  Bottom 0.152: 53.4,163.9 53.8,163.9
S$5258
  Bottom 0.152: 53.8,163.9 54.8,164.9
S$5259
  Bottom 0.152: 55.4,163.9 56.4,164.9
S$5260
  Bottom 0.152: 57.4,163.9 58,164.5
S$5261
  Bottom 0.152: 58,164.5 58,164.9
S$5262
  Bottom 0.152: 59.4,163.9 59.6,164.1
S$5263
  Bottom 0.152: 59.6,164.1 59.6,164.9
S$5264
  Bottom 0.152: 61.4,163.9 61.2,164.1
S$5265
  Bottom 0.152: 61.2,164.1 61.2,164.9
S$5266
  Bottom 0.152: 63.4,163.9 62.8,164.5
S$5267
  Bottom 0.152: 62.8,164.5 62.8,164.9
S$5268
  Bottom 0.152: 65.4,163.9 64.4,164.9
S$5269
  Bottom 0.152: 67.4,163.9 67,163.9
S$5270
  Bottom 0.152: 67,163.9 66,164.9
S$5271
  Bottom 0.152: 69.4,163.9 68.6,163.9
S$5272
  Bottom 0.152: 68.6,163.9 67.6,164.9
S$5273
  Bottom 0.152: 62.4,167.9 62,168.3
S$5274
  Bottom 0.152: 62,168.3 62,168.9
S$5275
  Bottom 0.152: 64.4,167.9 63.6,168.7
S$5276
  Bottom 0.152: 63.6,168.7 63.6,168.9
S$5277
  Bottom 0.152: 66.4,167.9 66.2,167.9
S$5278
  Bottom 0.152: 66.2,167.9 65.2,168.9
S$5279
  Bottom 0.152: 68.4,167.9 67.8,167.9
S$5280
  Bottom 0.152: 67.8,167.9 66.8,168.9
S$5281
  Bottom 0.152: 70.4,165.9 69.4,164.9
S$5282
  Bottom 0.152: 69.4,164.9 68.4,164.9
S$5283
  Bottom 0.152: 68.6,169.9 69.2,169.9
S$5284
  Bottom 0.152: 69.2,169.9 70.2,168.9
S$5285
  Bottom 0.152: 70.2,168.9 70.8,168.9
S$5286
  Bottom 0.152: 70.6,169.9 71.6,168.9
S$5287
  Bottom 0.152: 71.6,168.9 72.4,168.9
S$5288
  Bottom 0.152: 72.6,169.9 73.6,168.9
S$5289
  Bottom 0.152: 73.6,168.9 74,168.9
S$5290
  Bottom 0.152: 74.6,169.9 75.6,168.9
S$5291
  Bottom 0.152: 76.6,169.9 77.2,169.3
S$5292
  Bottom 0.152: 77.2,169.3 77.2,168.9
S$5293
  Bottom 0.152: 67.6,173.9 68.6,172.9
S$5294
  Bottom 0.152: 68.6,172.9 70,172.9
S$5295
  Bottom 0.152: 69.6,173.9 70,173.9
S$5296
  Bottom 0.152: 70,173.9 71,172.9
S$5297
  Bottom 0.152: 71,172.9 71.6,172.9
S$5298
  Bottom 0.152: 71.6,173.9 72.2,173.9
S$5299
  Bottom 0.152: 72.2,173.9 73.2,172.9
S$5300
  Bottom 0.152: 73.6,173.9 73.8,173.9
S$5301
  Bottom 0.152: 73.8,173.9 74.8,172.9
S$5302
  Bottom 0.152: 75.6,173.9 76.4,173.1
S$5303
  Bottom 0.152: 76.4,173.1 76.4,172.9
S$5304
  Bottom 0.152: 69.2,168.9 68,168.9
S$5305
  Bottom 0.152: 68,168.9 67,169.9
S$5306
  Bottom 0.152: 67,169.9 66.6,169.9
S$5307
  Bottom 0.152: 102.8,167.9 102.2,167.9
S$5308
  Bottom 0.152: 102.2,167.9 101.2,168.9
S$5309
  Bottom 0.152: 100.8,167.9 100.6,167.9
S$5310
  Bottom 0.152: 100.6,167.9 99.6,168.9
S$5311
  Bottom 0.152: 98.8,167.9 98,168.7
S$5312
  Bottom 0.152: 98,168.7 98,168.9
S$5313
  Bottom 0.152: 96.8,167.9 96.4,168.3
S$5314
  Bottom 0.152: 96.4,168.3 96.4,168.9
S$5315
  Bottom 0.152: 94.8,167.9 94.8,168.9
S$5316
  Bottom 0.152: 104.8,167.9 103.8,167.9
S$5317
  Bottom 0.152: 103.8,167.9 102.8,168.9
S$5318
  Bottom 0.152: 103.8,163.9 102.8,164.9
S$5319
  Bottom 0.152: 102.8,164.9 102,164.9
S$5320
  Bottom 0.152: 101.8,163.9 101.4,163.9
S$5321
  Bottom 0.152: 101.4,163.9 100.4,164.9
S$5322
  Bottom 0.152: 99.8,163.9 98.8,164.9
S$5323
  Bottom 0.152: 97.8,163.9 97.2,164.5
S$5324
  Bottom 0.152: 97.2,164.5 97.2,164.9
S$5325
  Bottom 0.152: 95.8,163.9 95.6,164.1
S$5326
  Bottom 0.152: 95.6,164.1 95.6,164.9
S$5327
  Bottom 0.152: 93.8,163.9 94,164.1
S$5328
  Bottom 0.152: 94,164.1 94,164.9
S$5329
  Bottom 0.152: 91.8,163.9 92.4,164.5
S$5330
  Bottom 0.152: 92.4,164.5 92.4,164.9
S$5331
  Bottom 0.152: 89.8,163.9 90.8,164.9
S$5332
  Bottom 0.152: 87.8,163.9 88.2,163.9
S$5333
  Bottom 0.152: 88.2,163.9 89.2,164.9
S$5334
  Bottom 0.152: 85.8,163.9 86.6,163.9
S$5335
  Bottom 0.152: 86.6,163.9 87.6,164.9
S$5336
  Bottom 0.152: 92.8,167.9 93.2,168.3
S$5337
  Bottom 0.152: 93.2,168.3 93.2,168.9
S$5338
  Bottom 0.152: 90.8,167.9 91.6,168.7
S$5339
  Bottom 0.152: 91.6,168.7 91.6,168.9
S$5340
  Bottom 0.152: 88.8,167.9 89,167.9
S$5341
  Bottom 0.152: 89,167.9 90,168.9
S$5342
  Bottom 0.152: 86.8,167.9 87.4,167.9
S$5343
  Bottom 0.152: 87.4,167.9 88.4,168.9
S$5344
  Bottom 0.152: 84.8,165.9 85.8,164.9
S$5345
  Bottom 0.152: 85.8,164.9 86.8,164.9
S$5346
  Bottom 0.152: 86.6,169.9 86,169.9
S$5347
  Bottom 0.152: 86,169.9 85,168.9
S$5348
  Bottom 0.152: 85,168.9 84.4,168.9
S$5349
  Bottom 0.152: 84.6,169.9 83.6,168.9
S$5350
  Bottom 0.152: 83.6,168.9 82.8,168.9
S$5351
  Bottom 0.152: 82.6,169.9 81.6,168.9
S$5352
  Bottom 0.152: 81.6,168.9 81.2,168.9
S$5353
  Bottom 0.152: 80.6,169.9 79.6,168.9
S$5354
  Bottom 0.152: 78.6,169.9 78,169.3
S$5355
  Bottom 0.152: 78,169.3 78,168.9
S$5356
  Bottom 0.152: 87.6,173.9 86.6,172.9
S$5357
  Bottom 0.152: 86.6,172.9 85.2,172.9
S$5358
  Bottom 0.152: 85.6,173.9 85.2,173.9
S$5359
  Bottom 0.152: 85.2,173.9 84.2,172.9
S$5360
  Bottom 0.152: 84.2,172.9 83.6,172.9
S$5361
  Bottom 0.152: 83.6,173.9 83,173.9
S$5362
  Bottom 0.152: 83,173.9 82,172.9
S$5363
  Bottom 0.152: 81.6,173.9 81.4,173.9
S$5364
  Bottom 0.152: 81.4,173.9 80.4,172.9
S$5365
  Bottom 0.152: 79.6,173.9 78.8,173.1
S$5366
  Bottom 0.152: 78.8,173.1 78.8,172.9
S$5367
  Bottom 0.152: 86,168.9 87.2,168.9
S$5368
  Bottom 0.152: 87.2,168.9 88.2,169.9
S$5369
  Bottom 0.152: 88.2,169.9 88.6,169.9
S$5370  (2 unrouted)
  Top 0.813: 117,173.4 117,164.4
  Top 1.8: 118,170.4 116,170.4 | 118,173.4 117,173.4 116,173.4 | 118,167.4 116,167.4 | 118,164.4 117,164.4 116,164.4
S$5371
  Top 1.778: -52.08,165.72 -52.08,167.25
S$5372
  Top 1.778: -52.08,170.55 -52.08,172.08
S$5373
  Top 1.778: -47,165.72 -47,167.25
S$5374
  Top 1.778: -47,170.55 -47,172.08
S$5375
  Top 1.778: -41.92,165.72 -41.92,167.25
S$5376
  Top 1.778: -41.92,170.55 -41.92,172.08
S$5377
  Top 1.778: 145.92,165.72 145.92,167.25
S$5378
  Top 1.778: 145.92,170.55 145.92,172.08
S$5379
  Top 1.778: 151,165.72 151,167.25
S$5380
  Top 1.778: 151,170.55 151,172.08
S$5381
  Top 1.778: 156.08,165.72 156.08,167.25
S$5382
  Top 1.778: 156.08,170.55 156.08,172.08
S$5383  (via drill 0.2)
  other vias: 26.4,175.3
S$5384  (via drill 0.2)
  other vias: 43.4,162.5
S$5385  (via drill 0.2)
  other vias: 60.6,175.3
S$5386  (via drill 0.2)
  other vias: 77.6,162.5
S$5387  (via drill 0.2)
  other vias: 93.6,175.3
S$5388  (via drill 0.2)
  other vias: 104.8,175.3
S$5389  (via drill 0.2)
  other vias: 10.4,162.5
S$5390  (via drill 0.2)
  other vias: -0.8,162.5
S$5391
  Top 0.813: -41.92,5.4 -41.92,7.9
S$5392
  Top 0.813: -41.92,23.4 -41.92,25.9
S$5393  (1 unrouted)
  Top 0.61: -13,27.9 -13,23.4 | -13,23.4 -13,21.9 | -13,23.4 -16.5,23.4 -18,24.9
  Top 0.813: -18,24.9 -41.5,24.9
  Top 1.8: -12,24.9 -14,24.9 | -12,27.9 -13,27.9 -14,27.9 | -12,21.9 -13,21.9 -14,21.9
S$5394
  Top 0.813: -41.92,41.4 -41.92,43.9
S$5395  (1 unrouted)
  Top 0.61: -13,45.9 -13,41.4 | -13,41.4 -13,39.9 | -13,41.4 -16.5,41.4 -18,42.9
  Top 0.813: -18,42.9 -41.5,42.9
  Top 1.8: -12,42.9 -14,42.9 | -12,45.9 -13,45.9 -14,45.9 | -12,39.9 -13,39.9 -14,39.9
S$5396
  Top 0.813: -41.92,59.4 -41.92,61.9
S$5397  (1 unrouted)
  Top 0.61: -13,63.9 -13,59.4 | -13,59.4 -13,57.9 | -13,59.4 -16.5,59.4 -18,60.9
  Top 0.813: -18,60.9 -41.5,60.9
  Top 1.8: -12,60.9 -14,60.9 | -12,63.9 -13,63.9 -14,63.9 | -12,57.9 -13,57.9 -14,57.9
S$5398
  Top 0.813: -41.92,77.4 -41.92,79.9
S$5399  (1 unrouted)
  Top 0.61: -13,81.9 -13,77.4 | -13,77.4 -13,75.9 | -13,77.4 -16.5,77.4 -18,78.9
  Top 0.813: -18,78.9 -41.5,78.9
  Top 1.8: -12,78.9 -14,78.9 | -12,81.9 -13,81.9 -14,81.9 | -12,75.9 -13,75.9 -14,75.9
S$5400
  Top 0.813: -41.92,95.4 -41.92,97.9
S$5401  (1 unrouted)
  Top 0.61: -13,99.9 -13,95.4 | -13,95.4 -13,93.9 | -13,95.4 -16.5,95.4 -18,96.9
  Top 0.813: -18,96.9 -41.5,96.9
  Top 1.8: -12,96.9 -14,96.9 | -12,99.9 -13,99.9 -14,99.9 | -12,93.9 -13,93.9 -14,93.9
S$5402
  Top 0.813: -41.92,113.4 -41.92,115.9
S$5403  (1 unrouted)
  Top 0.61: -13,117.9 -13,113.4 | -13,113.4 -13,111.9 | -13,113.4 -16.5,113.4 -18,114.9
  Top 0.813: -18,114.9 -41.5,114.9
  Top 1.8: -12,114.9 -14,114.9 | -12,117.9 -13,117.9 -14,117.9 | -12,111.9 -13,111.9 -14,111.9
S$5404
  Top 0.813: -41.92,131.4 -41.92,133.9
S$5405  (1 unrouted)
  Top 0.61: -13,135.9 -13,131.4 | -13,131.4 -13,129.9 | -13,131.4 -16.5,131.4 -18,132.9
  Top 0.813: -18,132.9 -41.5,132.9
  Top 1.8: -12,132.9 -14,132.9 | -12,135.9 -13,135.9 -14,135.9 | -12,129.9 -13,129.9 -14,129.9
S$5406
  Top 0.813: -41.92,149.4 -41.92,151.9
S$5407  (1 unrouted)
  Top 0.61: -13,153.9 -13,149.4 | -13,149.4 -13,147.9 | -13,149.4 -16.5,149.4 -18,150.9
  Top 0.813: -18,150.9 -41.5,150.9
  Top 1.8: -12,150.9 -14,150.9 | -12,153.9 -13,153.9 -14,153.9 | -12,147.9 -13,147.9 -14,147.9
S$5408
  Top 0.813: -41.92,167.4 -41.92,169.9
S$5409  (6 unrouted)
  Top 0.61: -13,171.9 -13,167.4 | -13,167.4 -13,165.9 | -13,167.4 -16.5,167.4 -18,168.9
  Top 0.813: -18,168.9 -41.5,168.9
  Top 1.8: -12,168.9 -14,168.9 | -12,171.9 -13,171.9 -14,171.9 | -12,165.9 -13,165.9 -14,165.9
  Top 2: 82,184.9 80,184.9 | 96,184.9 94,184.9
  Top 3: 53.5,184.9 50.5,184.9 | 104.5,184.9 101.5,184.9 | 2.5,184.9 -0.5,184.9
S$5410  (1 unrouted)
  Top 2: 10,184.9 8,184.9 | 24,184.9 22,184.9
S$5411  (1 unrouted)
  Top 2: 61,184.9 59,184.9 | 75,184.9 73,184.9
S$5412  (1 unrouted)
  Top 2: 145,186.9 143,186.9 | 159,186.9 157,186.9
S$5413  (2 unrouted)
  Top 0.508: 142,186.9 145,186.9
  Top 0.813: -46,186.9 -38,186.9 -36,188.9 -22,188.9 -18,184.9 2,184.9 8,184.9 | 75,184.9 80,184.9 | 103,184.9 120,184.9 124,188.9 140,188.9 142,186.9
S$5414
  Top 3: -44.5,186.9 -47.5,186.9
S$5415  (1 unrouted)
  Top 0.813: -70,-1.1 -66,-1.1 -59,-8.1 -14,-8.1 -13,-9.1 -4,-9.1 | -73,-9.1 -66,-9.1 -63,-12.1 -17,-12.1 -15,-14.1 9,-14.1 14,-9.1 108,-9.1
S$5416
  Top 3: -74.5,141.9 -77.5,141.9
S$5417  (7 unrouted)
  Top 2: -70,142.9 -70,140.9 | -70,156.9 -70,154.9 | -93,134.9 -95,134.9 | -75,134.9 -77,134.9
  Bottom 2: -107,130.9 -105,130.9 | -107,166.9 -105,166.9 | -107,8.9 -105,8.9 | -107,44.9 -105,44.9
S$5418
  Top 0.813: -76,182.9 -76,170.9
S$5419  (1 unrouted)
  Top 3: -74.5,33.9 -77.5,33.9 | -70.5,56.4 -70.5,53.4
S$5420  (2 unrouted)
  Top 0.813: -78,41.9 -76,41.9 | -76,41.9 -74,41.9 -76,41.9 | -76,41.9 -76,33.9
  Top 2: -74,41.9 -74,39.9 | -74,55.9 -74,53.9 | -95,41.9 -97,41.9 | -77,41.9 -78,41.9 -79,41.9
S$5421
  Top 0.813: -74,54.9 -70.5,54.9
S$5422  (via drill 4.2)  (3 unrouted)
  other vias: -47,195.9 -65,195.9 -83,195.9 -101,195.9
S$5423  (via drill 4.2)
  other vias: -47,-20.1
S$5424  (via drill 4.2)
  other vias: -65,-20.1
S$5425  (via drill 4.2)
  other vias: -83,-20.1
S$5426  (1 unrouted)
  Top 2: 145,180.9 143,180.9 | 159,180.9 157,180.9
S$5427  (via drill 4.2)  (6 unrouted)
  other vias: -101,15.9 -101,51.9 -101,159.9 -101,123.9 -101,-20.1 -101,87.9
S$5428  (via drill 4.2)
  other vias: 151,-20.1
S$5429  (via drill 4.2)
  other vias: 169,-20.1
S$5430  (via drill 4.2)
  other vias: 169,-2.1
S$5431  (via drill 4.2)
  other vias: 151,195.9
S$5432  (via drill 4.2)
  other vias: 169,195.9
S$5433  (via drill 4.2)  (9 unrouted)
  other vias: 169,177.9 169,159.9 169,141.9 169,123.9 169,105.9 169,87.9 169,69.9 169,51.9 169,33.9 169,15.9
S$5434  (1 unrouted)
  Top 0.813: -47,170.9 -47,3.9 | 151,170.9 151,3.9
S$5435
  Top 0.813: -76,134.9 -76,141.9 -70,141.9
S$5437
  Top 3: -74.5,177.9 -77.5,177.9
S$5438  (3 unrouted)
  Top 2: -62,182.9 -60,182.9 | -76,182.9 -74,182.9 | -93,170.9 -95,170.9 | -75,170.9 -77,170.9
S$5439  (1 unrouted)
  Top 0.813: 144,-9.1 144,-5.1 151,0.9 151,4.9
  Top 2: 144,-9.1 142,-9.1 | 162,-9.1 160,-9.1
S$5441
  Top 3: -71.5,-9.1 -74.5,-9.1
S$5442
  Top 0.508: 158,180.9 156,180.9
  Top 0.813: 156,180.9 151,173.9 151,171.9
S$5443
  Top 0.813: 117.1,24.9 145.9,24.9
S$5444
  Top 0.813: 145.9,26.9 145.9,22.9
S$5445
  Top 3: -71.5,-1.1 -74.5,-1.1
S$5446  (1 unrouted)
  Top 3: -2.5,-9.1 -5.5,-9.1 | 109.5,-9.1 106.5,-9.1
S$5447
  Top 0.813: 117.1,42.9 145.9,42.9
S$5448
  Top 0.813: 145.9,44.9 145.9,40.9
S$5449
  Top 0.813: 117.1,60.9 145.9,60.9
S$5450
  Top 0.813: 145.9,62.9 145.9,58.9
S$5451
  Top 0.813: 117.1,78.9 145.9,78.9
S$5452
  Top 0.813: 145.9,80.9 145.9,76.9
S$5453
  Top 0.813: 117.1,96.9 145.9,96.9
S$5454
  Top 0.813: 145.9,98.9 145.9,94.9
S$5455
  Top 0.813: 117.1,114.9 145.9,114.9
S$5456
  Top 0.813: 145.9,116.9 145.9,112.9
S$5457
  Top 0.813: 117.1,132.9 145.9,132.9
S$5458
  Top 0.813: 145.9,134.9 145.9,130.9
S$5459
  Top 0.813: 117.1,150.9 145.9,150.9
S$5460
  Top 0.813: 145.9,152.9 145.9,148.9
S$5461
  Top 0.813: 117.1,168.9 145.9,168.9
S$5462
  Top 0.813: 145.9,170.9 145.9,166.9
S$5463
  Top 0.813: 117.1,6.9 145.9,6.9
S$5464
  Top 0.813: 145.9,8.9 145.9,4.9
S$5465
  Top 0.813: -70,156.9 -70,157.9 -68,159.9 -47,159.9
S$5466
  Top 0.813: 54,184.9 59,184.9
S$5467
  Top 0.813: 158,186.9 168,186.9
S$5468  (1 unrouted)
  Top 2: 31,184.9 29,184.9 | 45,184.9 43,184.9
S$5469  (1 unrouted)
  Top 0.813: 23,184.9 29,184.9 | 44,184.9 50,184.9
S$5470
  Top 0.813: -60,182.9 -58,182.9 -56,180.9 -38,180.9 -34,184.9 -24,184.9 -20,180.9 123,180.9 127,184.9 137,184.9 141,180.9 145,180.9
(copper drawn outside any net)
  shapes: Top area x1280

## Text on the board
Dimension: 00.0 / - 08.4 / 16.8 / - 25.6 / 34.4 / - 42.8 / 51.2
tDocu: FieldW | Gnd | SkirtTop | SkirtBot | ZeroGrid | SenseW | Gas | Cathode | GatingG
THT: --R-- | --R-- | --R-- | --R-- | --R-- | --R-- | --R-- | --C-- | --R-- | --C-- | --R-- | --C-- | --C--
CageSupp: R6 / R10
Remarks: Hv:Cath / PadP-FcB | Hv:Cath / FcB-Cath