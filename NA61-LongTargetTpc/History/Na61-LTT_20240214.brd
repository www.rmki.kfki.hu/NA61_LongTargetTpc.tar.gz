# EAGLE board Na61-LTT_20240214 (EAGLE 9.6.2), part 3 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$2331  (via drill 0.2) (continued)
  other vias: 45.2,82.9
S$2332  (via drill 0.2)
  other vias: 43.6,82.9
S$2333  (via drill 0.2)
  other vias: 42,82.9
S$2334  (via drill 0.2)
  other vias: 40.4,82.9
S$2335  (via drill 0.2)
  other vias: 38.8,82.9
S$2336  (via drill 0.2)
  other vias: 37.2,82.9
S$2337  (via drill 0.2)
  other vias: 35.6,82.9
S$2338  (via drill 0.2)
  other vias: 50.8,78.9
S$2339  (via drill 0.2)
  other vias: 49.2,78.9
S$2340  (via drill 0.2)
  other vias: 47.6,78.9
S$2341  (via drill 0.2)
  other vias: 46,78.9
S$2342  (via drill 0.2)
  other vias: 44.4,78.9
S$2343  (via drill 0.2)
  other vias: 42.8,78.9
S$2344  (via drill 0.2)
  other vias: 41.2,78.9
S$2345  (via drill 0.2)
  other vias: 39.6,78.9
S$2346  (via drill 0.2)
  other vias: 38,78.9
S$2347  (via drill 0.2)
  other vias: 36.4,78.9
S$2348  (via drill 0.2)
  other vias: 34.8,74.9
S$2349  (via drill 0.2)
  other vias: 33.2,74.9
S$2350  (via drill 0.2)
  other vias: 31.6,74.9
S$2351  (via drill 0.2)
  other vias: 30,74.9
S$2352  (via drill 0.2)
  other vias: 28.4,74.9
S$2353  (via drill 0.2)
  other vias: 34,78.9
S$2354  (via drill 0.2)
  other vias: 32.4,78.9
S$2355  (via drill 0.2)
  other vias: 30.8,78.9
S$2356  (via drill 0.2)
  other vias: 29.2,78.9
S$2357  (via drill 0.2)
  other vias: 27.6,78.9
S$2358  (via drill 0.2)
  other vias: 26.8,74.9
S$2359  (via drill 0.2)
  other vias: 52.4,78.9
S$2360  (via drill 0.2)
  other vias: 54,78.9
S$2361  (via drill 0.2)
  other vias: 55.6,78.9
S$2362  (via drill 0.2)
  other vias: 57.2,78.9
S$2363  (via drill 0.2)
  other vias: 58.8,78.9
S$2364  (via drill 0.2)
  other vias: 60.4,78.9
S$2365  (via drill 0.2)
  other vias: 62,78.9
S$2366  (via drill 0.2)
  other vias: 63.6,78.9
S$2367  (via drill 0.2)
  other vias: 65.2,78.9
S$2368  (via drill 0.2)
  other vias: 66.8,78.9
S$2369  (via drill 0.2)
  other vias: 68.4,74.9
S$2370  (via drill 0.2)
  other vias: 53.2,74.9
S$2371  (via drill 0.2)
  other vias: 54.8,74.9
S$2372  (via drill 0.2)
  other vias: 56.4,74.9
S$2373  (via drill 0.2)
  other vias: 58,74.9
S$2374  (via drill 0.2)
  other vias: 59.6,74.9
S$2375  (via drill 0.2)
  other vias: 61.2,74.9
S$2376  (via drill 0.2)
  other vias: 62.8,74.9
S$2377  (via drill 0.2)
  other vias: 64.4,74.9
S$2378  (via drill 0.2)
  other vias: 66,74.9
S$2379  (via drill 0.2)
  other vias: 67.6,74.9
S$2380  (via drill 0.2)
  other vias: 69.2,78.9
S$2381  (via drill 0.2)
  other vias: 70.8,78.9
S$2382  (via drill 0.2)
  other vias: 72.4,78.9
S$2383  (via drill 0.2)
  other vias: 70,82.9
S$2384  (via drill 0.2)
  other vias: 71.6,82.9
S$2385  (via drill 0.2)
  other vias: 73.2,82.9
S$2386  (via drill 0.2)
  other vias: 74,78.9
S$2387  (via drill 0.2)
  other vias: 74.8,82.9
S$2388  (via drill 0.2)
  other vias: 75.6,78.9
S$2389  (via drill 0.2)
  other vias: 76.4,82.9
S$2390  (via drill 0.2)
  other vias: 77.2,78.9
S$2391  (via drill 0.2)
  other vias: 102.8,78.9
S$2392  (via drill 0.2)
  other vias: 101.2,78.9
S$2393  (via drill 0.2)
  other vias: 99.6,78.9
S$2394  (via drill 0.2)
  other vias: 98,78.9
S$2395  (via drill 0.2)
  other vias: 96.4,78.9
S$2396  (via drill 0.2)
  other vias: 94.8,78.9
S$2397  (via drill 0.2)
  other vias: 93.2,78.9
S$2398  (via drill 0.2)
  other vias: 91.6,78.9
S$2399  (via drill 0.2)
  other vias: 90,78.9
S$2400  (via drill 0.2)
  other vias: 88.4,78.9
S$2401  (via drill 0.2)
  other vias: 86.8,74.9
S$2402  (via drill 0.2)
  other vias: 102,74.9
S$2403  (via drill 0.2)
  other vias: 100.4,74.9
S$2404  (via drill 0.2)
  other vias: 98.8,74.9
S$2405  (via drill 0.2)
  other vias: 97.2,74.9
S$2406  (via drill 0.2)
  other vias: 95.6,74.9
S$2407  (via drill 0.2)
  other vias: 94,74.9
S$2408  (via drill 0.2)
  other vias: 92.4,74.9
S$2409  (via drill 0.2)
  other vias: 90.8,74.9
S$2410  (via drill 0.2)
  other vias: 89.2,74.9
S$2411  (via drill 0.2)
  other vias: 87.6,74.9
S$2412  (via drill 0.2)
  other vias: 86,78.9
S$2413  (via drill 0.2)
  other vias: 84.4,78.9
S$2414  (via drill 0.2)
  other vias: 82.8,78.9
S$2415  (via drill 0.2)
  other vias: 85.2,82.9
S$2416  (via drill 0.2)
  other vias: 83.6,82.9
S$2417  (via drill 0.2)
  other vias: 82,82.9
S$2418  (via drill 0.2)
  other vias: 81.2,78.9
S$2419  (via drill 0.2)
  other vias: 80.4,82.9
S$2420  (via drill 0.2)
  other vias: 79.6,78.9
S$2421  (via drill 0.2)
  other vias: 78.8,82.9
S$2422  (via drill 0.2)
  other vias: 78,78.9
S$2423
  Bottom 0.152: -0.8,83.9 0.2,82.9
S$2424
  Bottom 0.152: 0.2,82.9 1.2,82.9
S$2425
  Bottom 0.152: 1.2,83.9 1.8,83.9
S$2426
  Bottom 0.152: 1.8,83.9 2.8,82.9
S$2427
  Bottom 0.152: 3.2,83.9 3.4,83.9
S$2428
  Bottom 0.152: 3.4,83.9 4.4,82.9
S$2429
  Bottom 0.152: 5.2,83.9 6,83.1
S$2430
  Bottom 0.152: 6,83.1 6,82.9
S$2431
  Bottom 0.152: 7.2,83.9 7.6,83.5
S$2432
  Bottom 0.152: 7.6,83.5 7.6,82.9
S$2433
  Bottom 0.152: 9.2,83.9 9.2,82.9
S$2434
  Bottom 0.152: 11.2,83.9 10.8,83.5
S$2435
  Bottom 0.152: 10.8,83.5 10.8,82.9
S$2436
  Bottom 0.152: 13.2,83.9 12.4,83.1
S$2437
  Bottom 0.152: 12.4,83.1 12.4,82.9
S$2438
  Bottom 0.152: 15.2,83.9 15,83.9
S$2439
  Bottom 0.152: 15,83.9 14,82.9
S$2440
  Bottom 0.152: 17.2,83.9 16.6,83.9
S$2441
  Bottom 0.152: 16.6,83.9 15.6,82.9
S$2442
  Bottom 0.152: 19.2,83.9 18.2,82.9
S$2443
  Bottom 0.152: 18.2,82.9 17.2,82.9
S$2444
  Bottom 0.152: 0.2,79.9 1.2,78.9
S$2445
  Bottom 0.152: 1.2,78.9 2,78.9
S$2446
  Bottom 0.152: 2.2,79.9 3.2,78.9
S$2447
  Bottom 0.152: 3.2,78.9 3.6,78.9
S$2448
  Bottom 0.152: 4.2,79.9 5.2,78.9
S$2449
  Bottom 0.152: 6.2,79.9 6.8,79.3
S$2450
  Bottom 0.152: 6.8,79.3 6.8,78.9
S$2451
  Bottom 0.152: 8.2,79.9 8.4,79.7
S$2452
  Bottom 0.152: 8.4,79.7 8.4,78.9
S$2453
  Bottom 0.152: 10.2,79.9 10,79.7
S$2454
  Bottom 0.152: 10,79.7 10,78.9
S$2455
  Bottom 0.152: 12.2,79.9 11.6,79.3
S$2456
  Bottom 0.152: 11.6,79.3 11.6,78.9
S$2457
  Bottom 0.152: 14.2,79.9 13.2,78.9
S$2458
  Bottom 0.152: 16.2,79.9 15.2,78.9
S$2459
  Bottom 0.152: 15.2,78.9 14.8,78.9
S$2460
  Bottom 0.152: 18.2,79.9 17.2,78.9
S$2461
  Bottom 0.152: 17.2,78.9 16.4,78.9
S$2462
  Bottom 0.152: 15.4,73.9 16.4,74.9
S$2463
  Bottom 0.152: 16.4,74.9 18,74.9
S$2464
  Bottom 0.152: 17.4,73.9 18.2,73.9
S$2465
  Bottom 0.152: 18.2,73.9 19.2,74.9
S$2466
  Bottom 0.152: 19.2,74.9 19.6,74.9
S$2467
  Bottom 0.152: 19.4,73.9 20.2,73.9
S$2468
  Bottom 0.152: 20.2,73.9 21.2,74.9
S$2469
  Bottom 0.152: 21.4,73.9 21.8,73.9
S$2470
  Bottom 0.152: 21.8,73.9 22.8,74.9
S$2471
  Bottom 0.152: 23.4,73.9 24.4,74.9
S$2472
  Bottom 0.152: 25.4,73.9 26,74.5
S$2473
  Bottom 0.152: 26,74.5 26,74.9
S$2474
  Bottom 0.152: 16.4,77.9 17,77.9
S$2475
  Bottom 0.152: 17,77.9 18,78.9
S$2476
  Bottom 0.152: 18,78.9 18.8,78.9
S$2477
  Bottom 0.152: 18.4,77.9 19,77.9
S$2478
  Bottom 0.152: 19,77.9 20,78.9
S$2479
  Bottom 0.152: 20,78.9 20.4,78.9
S$2480
  Bottom 0.152: 20.4,77.9 21,77.9
S$2481
  Bottom 0.152: 21,77.9 22,78.9
S$2482
  Bottom 0.152: 22.4,77.9 22.6,77.9
S$2483
  Bottom 0.152: 22.6,77.9 23.6,78.9
S$2484
  Bottom 0.152: 24.4,77.9 25.2,78.7
S$2485
  Bottom 0.152: 25.2,78.7 25.2,78.9
S$2486
  Bottom 0.152: 53.6,83.9 52.6,82.9
S$2487
  Bottom 0.152: 52.6,82.9 51.6,82.9
S$2488
  Bottom 0.152: 51.6,83.9 51,83.9
S$2489
  Bottom 0.152: 51,83.9 50,82.9
S$2490
  Bottom 0.152: 49.6,83.9 49.4,83.9
S$2491
  Bottom 0.152: 49.4,83.9 48.4,82.9
S$2492
  Bottom 0.152: 47.6,83.9 46.8,83.1
S$2493
  Bottom 0.152: 46.8,83.1 46.8,82.9
S$2494
  Bottom 0.152: 45.6,83.9 45.2,83.5
S$2495
  Bottom 0.152: 45.2,83.5 45.2,82.9
S$2496
  Bottom 0.152: 43.6,83.9 43.6,82.9
S$2497
  Bottom 0.152: 41.6,83.9 42,83.5
S$2498
  Bottom 0.152: 42,83.5 42,82.9
S$2499
  Bottom 0.152: 39.6,83.9 40.4,83.1
S$2500
  Bottom 0.152: 40.4,83.1 40.4,82.9
S$2501
  Bottom 0.152: 37.6,83.9 37.8,83.9
S$2502
  Bottom 0.152: 37.8,83.9 38.8,82.9
S$2503
  Bottom 0.152: 35.6,83.9 36.2,83.9
S$2504
  Bottom 0.152: 36.2,83.9 37.2,82.9
S$2505
  Bottom 0.152: 33.6,83.9 34.6,82.9
S$2506
  Bottom 0.152: 34.6,82.9 35.6,82.9
S$2507
  Bottom 0.152: 52.6,79.9 51.6,78.9
S$2508
  Bottom 0.152: 51.6,78.9 50.8,78.9
S$2509
  Bottom 0.152: 50.6,79.9 49.6,78.9
S$2510
  Bottom 0.152: 49.6,78.9 49.2,78.9
S$2511
  Bottom 0.152: 48.6,79.9 47.6,78.9
S$2512
  Bottom 0.152: 46.6,79.9 46,79.3
S$2513
  Bottom 0.152: 46,79.3 46,78.9
S$2514
  Bottom 0.152: 44.6,79.9 44.4,79.7
S$2515
  Bottom 0.152: 44.4,79.7 44.4,78.9
S$2516
  Bottom 0.152: 42.6,79.9 42.8,79.7
S$2517
  Bottom 0.152: 42.8,79.7 42.8,78.9
S$2518
  Bottom 0.152: 40.6,79.9 41.2,79.3
S$2519
  Bottom 0.152: 41.2,79.3 41.2,78.9
S$2520
  Bottom 0.152: 38.6,79.9 39.6,78.9
S$2521
  Bottom 0.152: 36.6,79.9 37.6,78.9
S$2522
  Bottom 0.152: 37.6,78.9 38,78.9
S$2523
  Bottom 0.152: 34.6,79.9 35.6,78.9
S$2524
  Bottom 0.152: 35.6,78.9 36.4,78.9
S$2525
  Bottom 0.152: 37.4,73.9 36.4,74.9
S$2526
  Bottom 0.152: 36.4,74.9 34.8,74.9
S$2527
  Bottom 0.152: 35.4,73.9 34.6,73.9
S$2528
  Bottom 0.152: 34.6,73.9 33.6,74.9
S$2529
  Bottom 0.152: 33.6,74.9 33.2,74.9
S$2530
  Bottom 0.152: 33.4,73.9 32.6,73.9
S$2531
  Bottom 0.152: 32.6,73.9 31.6,74.9
S$2532
  Bottom 0.152: 31.4,73.9 31,73.9
S$2533
  Bottom 0.152: 31,73.9 30,74.9
S$2534
  Bottom 0.152: 29.4,73.9 28.4,74.9
S$2535
  Bottom 0.152: 27.4,73.9 26.8,74.5
S$2536
  Bottom 0.152: 26.8,74.5 26.8,74.9
S$2537
  Bottom 0.152: 36.4,77.9 35.8,77.9
S$2538
  Bottom 0.152: 35.8,77.9 34.8,78.9
S$2539
  Bottom 0.152: 34.8,78.9 34,78.9
S$2540
  Bottom 0.152: 34.4,77.9 33.8,77.9
S$2541
  Bottom 0.152: 33.8,77.9 32.8,78.9
S$2542
  Bottom 0.152: 32.8,78.9 32.4,78.9
S$2543
  Bottom 0.152: 32.4,77.9 31.8,77.9
S$2544
  Bottom 0.152: 31.8,77.9 30.8,78.9
S$2545
  Bottom 0.152: 30.4,77.9 30.2,77.9
S$2546
  Bottom 0.152: 30.2,77.9 29.2,78.9
S$2547
  Bottom 0.152: 28.4,77.9 27.6,78.7
S$2548
  Bottom 0.152: 27.6,78.7 27.6,78.9
S$2549
  Bottom 0.152: 52.4,77.9 53,77.9
S$2550
  Bottom 0.152: 53,77.9 54,78.9
S$2551
  Bottom 0.152: 54.4,77.9 54.6,77.9
S$2552
  Bottom 0.152: 54.6,77.9 55.6,78.9
S$2553
  Bottom 0.152: 56.4,77.9 57.2,78.7
S$2554
  Bottom 0.152: 57.2,78.7 57.2,78.9
S$2555
  Bottom 0.152: 58.4,77.9 58.8,78.3
S$2556
  Bottom 0.152: 58.8,78.3 58.8,78.9
S$2557
  Bottom 0.152: 60.4,77.9 60.4,78.9
S$2558
  Bottom 0.152: 50.4,77.9 51.4,77.9
S$2559
  Bottom 0.152: 51.4,77.9 52.4,78.9
S$2560
  Bottom 0.152: 51.4,73.9 52.4,74.9
S$2561
  Bottom 0.152: 52.4,74.9 53.2,74.9
S$2562
  Bottom 0.152: 53.4,73.9 53.8,73.9
S$2563
  Bottom 0.152: 53.8,73.9 54.8,74.9
S$2564
  Bottom 0.152: 55.4,73.9 56.4,74.9
S$2565
  Bottom 0.152: 57.4,73.9 58,74.5
S$2566
  Bottom 0.152: 58,74.5 58,74.9
S$2567
  Bottom 0.152: 59.4,73.9 59.6,74.1
S$2568
  Bottom 0.152: 59.6,74.1 59.6,74.9
S$2569
  Bottom 0.152: 61.4,73.9 61.2,74.1
S$2570
  Bottom 0.152: 61.2,74.1 61.2,74.9
S$2571
  Bottom 0.152: 63.4,73.9 62.8,74.5
S$2572
  Bottom 0.152: 62.8,74.5 62.8,74.9
S$2573
  Bottom 0.152: 65.4,73.9 64.4,74.9
S$2574
  Bottom 0.152: 67.4,73.9 67,73.9
S$2575
  Bottom 0.152: 67,73.9 66,74.9
S$2576
  Bottom 0.152: 69.4,73.9 68.6,73.9
S$2577
  Bottom 0.152: 68.6,73.9 67.6,74.9
S$2578
  Bottom 0.152: 62.4,77.9 62,78.3
S$2579
  Bottom 0.152: 62,78.3 62,78.9
S$2580
  Bottom 0.152: 64.4,77.9 63.6,78.7
S$2581
  Bottom 0.152: 63.6,78.7 63.6,78.9
S$2582
  Bottom 0.152: 66.4,77.9 66.2,77.9
S$2583
  Bottom 0.152: 66.2,77.9 65.2,78.9
S$2584
  Bottom 0.152: 68.4,77.9 67.8,77.9
S$2585
  Bottom 0.152: 67.8,77.9 66.8,78.9
S$2586
  Bottom 0.152: 70.4,75.9 69.4,74.9
S$2587
  Bottom 0.152: 69.4,74.9 68.4,74.9
S$2588
  Bottom 0.152: 68.6,79.9 69.2,79.9
S$2589
  Bottom 0.152: 69.2,79.9 70.2,78.9
S$2590
  Bottom 0.152: 70.2,78.9 70.8,78.9
S$2591
  Bottom 0.152: 70.6,79.9 71.6,78.9
S$2592
  Bottom 0.152: 71.6,78.9 72.4,78.9
S$2593
  Bottom 0.152: 72.6,79.9 73.6,78.9
S$2594
  Bottom 0.152: 73.6,78.9 74,78.9
S$2595
  Bottom 0.152: 74.6,79.9 75.6,78.9
S$2596
  Bottom 0.152: 76.6,79.9 77.2,79.3
S$2597
  Bottom 0.152: 77.2,79.3 77.2,78.9
S$2598
  Bottom 0.152: 67.6,83.9 68.6,82.9
S$2599
  Bottom 0.152: 68.6,82.9 70,82.9
S$2600
  Bottom 0.152: 69.6,83.9 70,83.9
S$2601
  Bottom 0.152: 70,83.9 71,82.9
S$2602
  Bottom 0.152: 71,82.9 71.6,82.9
S$2603
  Bottom 0.152: 71.6,83.9 72.2,83.9
S$2604
  Bottom 0.152: 72.2,83.9 73.2,82.9
S$2605
  Bottom 0.152: 73.6,83.9 73.8,83.9
S$2606
  Bottom 0.152: 73.8,83.9 74.8,82.9
S$2607
  Bottom 0.152: 75.6,83.9 76.4,83.1
S$2608
  Bottom 0.152: 76.4,83.1 76.4,82.9
S$2609
  Bottom 0.152: 69.2,78.9 68,78.9
S$2610
  Bottom 0.152: 68,78.9 67,79.9
S$2611
  Bottom 0.152: 67,79.9 66.6,79.9
S$2612
  Bottom 0.152: 102.8,77.9 102.2,77.9
S$2613
  Bottom 0.152: 102.2,77.9 101.2,78.9
S$2614
  Bottom 0.152: 100.8,77.9 100.6,77.9
S$2615
  Bottom 0.152: 100.6,77.9 99.6,78.9
S$2616
  Bottom 0.152: 98.8,77.9 98,78.7
S$2617
  Bottom 0.152: 98,78.7 98,78.9
S$2618
  Bottom 0.152: 96.8,77.9 96.4,78.3
S$2619
  Bottom 0.152: 96.4,78.3 96.4,78.9
S$2620
  Bottom 0.152: 94.8,77.9 94.8,78.9
S$2621
  Bottom 0.152: 104.8,77.9 103.8,77.9
S$2622
  Bottom 0.152: 103.8,77.9 102.8,78.9
S$2623
  Bottom 0.152: 103.8,73.9 102.8,74.9
S$2624
  Bottom 0.152: 102.8,74.9 102,74.9
S$2625
  Bottom 0.152: 101.8,73.9 101.4,73.9
S$2626
  Bottom 0.152: 101.4,73.9 100.4,74.9
S$2627
  Bottom 0.152: 99.8,73.9 98.8,74.9
S$2628
  Bottom 0.152: 97.8,73.9 97.2,74.5
S$2629
  Bottom 0.152: 97.2,74.5 97.2,74.9
S$2630
  Bottom 0.152: 95.8,73.9 95.6,74.1
S$2631
  Bottom 0.152: 95.6,74.1 95.6,74.9
S$2632
  Bottom 0.152: 93.8,73.9 94,74.1
S$2633
  Bottom 0.152: 94,74.1 94,74.9
S$2634
  Bottom 0.152: 91.8,73.9 92.4,74.5
S$2635
  Bottom 0.152: 92.4,74.5 92.4,74.9
S$2636
  Bottom 0.152: 89.8,73.9 90.8,74.9
S$2637
  Bottom 0.152: 87.8,73.9 88.2,73.9
S$2638
  Bottom 0.152: 88.2,73.9 89.2,74.9
S$2639
  Bottom 0.152: 85.8,73.9 86.6,73.9
S$2640
  Bottom 0.152: 86.6,73.9 87.6,74.9
S$2641
  Bottom 0.152: 92.8,77.9 93.2,78.3
S$2642
  Bottom 0.152: 93.2,78.3 93.2,78.9
S$2643
  Bottom 0.152: 90.8,77.9 91.6,78.7
S$2644
  Bottom 0.152: 91.6,78.7 91.6,78.9
S$2645
  Bottom 0.152: 88.8,77.9 89,77.9
S$2646
  Bottom 0.152: 89,77.9 90,78.9
S$2647
  Bottom 0.152: 86.8,77.9 87.4,77.9
S$2648
  Bottom 0.152: 87.4,77.9 88.4,78.9
S$2649
  Bottom 0.152: 84.8,75.9 85.8,74.9
S$2650
  Bottom 0.152: 85.8,74.9 86.8,74.9
S$2651
  Bottom 0.152: 86.6,79.9 86,79.9
S$2652
  Bottom 0.152: 86,79.9 85,78.9
S$2653
  Bottom 0.152: 85,78.9 84.4,78.9
S$2654
  Bottom 0.152: 84.6,79.9 83.6,78.9
S$2655
  Bottom 0.152: 83.6,78.9 82.8,78.9
S$2656
  Bottom 0.152: 82.6,79.9 81.6,78.9
S$2657
  Bottom 0.152: 81.6,78.9 81.2,78.9
S$2658
  Bottom 0.152: 80.6,79.9 79.6,78.9
S$2659
  Bottom 0.152: 78.6,79.9 78,79.3
S$2660
  Bottom 0.152: 78,79.3 78,78.9
S$2661
  Bottom 0.152: 87.6,83.9 86.6,82.9
S$2662
  Bottom 0.152: 86.6,82.9 85.2,82.9
S$2663
  Bottom 0.152: 85.6,83.9 85.2,83.9
S$2664
  Bottom 0.152: 85.2,83.9 84.2,82.9
S$2665
  Bottom 0.152: 84.2,82.9 83.6,82.9
S$2666
  Bottom 0.152: 83.6,83.9 83,83.9
S$2667
  Bottom 0.152: 83,83.9 82,82.9
S$2668
  Bottom 0.152: 81.6,83.9 81.4,83.9
S$2669
  Bottom 0.152: 81.4,83.9 80.4,82.9
S$2670
  Bottom 0.152: 79.6,83.9 78.8,83.1
S$2671
  Bottom 0.152: 78.8,83.1 78.8,82.9
S$2672
  Bottom 0.152: 86,78.9 87.2,78.9
S$2673
  Bottom 0.152: 87.2,78.9 88.2,79.9
S$2674
  Bottom 0.152: 88.2,79.9 88.6,79.9
S$2675  (2 unrouted)
  Top 0.813: 117,83.4 117,74.4
  Top 1.8: 118,80.4 116,80.4 | 118,83.4 117,83.4 116,83.4 | 118,77.4 116,77.4 | 118,74.4 117,74.4 116,74.4
S$2676
  Top 1.778: -52.08,75.73 -52.08,77.25
S$2677
  Top 1.778: -52.08,80.55 -52.08,82.08
S$2678
  Top 1.778: -47,75.73 -47,77.25
S$2679
  Top 1.778: -47,80.55 -47,82.08
S$2680
  Top 1.778: -41.92,75.73 -41.92,77.25
S$2681
  Top 1.778: -41.92,80.55 -41.92,82.08
S$2682
  Top 1.778: 145.92,75.73 145.92,77.25
S$2683
  Top 1.778: 145.92,80.55 145.92,82.08
S$2684
  Top 1.778: 151,75.73 151,77.25
S$2685
  Top 1.778: 151,80.55 151,82.08
S$2686
  Top 1.778: 156.08,75.73 156.08,77.25
S$2687
  Top 1.778: 156.08,80.55 156.08,82.08
S$2688  (via drill 0.2)
  other vias: 26.4,85.3
S$2689  (via drill 0.2)
  other vias: 43.4,72.5
S$2690  (via drill 0.2)
  other vias: 60.6,85.3
S$2691  (via drill 0.2)
  other vias: 77.6,72.5
S$2692  (via drill 0.2)
  other vias: 93.6,85.3
S$2693  (via drill 0.2)
  other vias: 104.8,85.3
S$2694  (via drill 0.2)
  other vias: 10.4,72.5
S$2695  (via drill 0.2)
  other vias: -0.8,72.5
S$2696
  Bottom 0.8: 61.4,91.8 61.4,90
S$2697
  Bottom 0.8: 63.4,91.8 63.4,90
S$2698
  Bottom 0.8: 60.4,94 60.4,95.8
S$2699
  Bottom 0.8: 62.4,94 62.4,95.8
S$2700
  Bottom 0.8: 57.4,91.8 57.4,90
S$2701
  Bottom 0.8: 59.4,91.8 59.4,90
S$2702
  Bottom 0.8: 58.4,94 58.4,95.8
S$2703
  Bottom 0.8: 56.4,94 56.4,95.8
S$2704
  Bottom 0.8: 55.4,91.8 55.4,90
S$2705
  Bottom 0.8: 53.4,91.8 53.4,90
S$2706
  Bottom 0.8: 54.4,94 54.4,95.8
S$2707
  Bottom 0.8: 52.4,94 52.4,95.8
S$2708
  Bottom 0.8: 51.4,91.8 51.4,90
S$2709
  Bottom 0.8: 49.4,91.8 49.4,90
S$2710
  Bottom 0.8: 50.4,94 50.4,95.8
S$2711
  Bottom 0.8: 69.4,91.8 69.4,90
S$2712
  Bottom 0.8: 71.4,91.8 71.4,90
S$2713
  Bottom 0.8: 68.4,94 68.4,95.8
S$2714
  Bottom 0.8: 70.4,94 70.4,95.8
S$2715
  Bottom 0.8: 65.4,91.8 65.4,90
S$2716
  Bottom 0.8: 67.4,91.8 67.4,90
S$2717
  Bottom 0.8: 64.4,94 64.4,95.8
S$2718
  Bottom 0.8: 66.4,94 66.4,95.8
S$2719
  Bottom 0.8: 44.6,99.8 44.6,98
S$2720
  Bottom 0.8: 46.6,99.8 46.6,98
S$2721
  Bottom 0.8: 43.6,102 43.6,103.8
S$2722
  Bottom 0.8: 45.6,102 45.6,103.8
S$2723
  Bottom 0.8: 40.6,99.8 40.6,98
S$2724
  Bottom 0.8: 42.6,99.8 42.6,98
S$2725
  Bottom 0.8: 41.6,102 41.6,103.8
S$2726
  Bottom 0.8: 39.6,102 39.6,103.8
S$2727
  Bottom 0.8: 38.6,99.8 38.6,98
S$2728
  Bottom 0.8: 36.6,99.8 36.6,98
S$2729
  Bottom 0.8: 37.6,102 37.6,103.8
S$2730
  Bottom 0.8: 35.6,102 35.6,103.8
S$2731
  Bottom 0.8: 34.6,99.8 34.6,98
S$2732
  Bottom 0.8: 32.6,99.8 32.6,98
S$2733
  Bottom 0.8: 33.6,102 33.6,103.8
S$2734
  Bottom 0.8: 52.6,99.8 52.6,98
S$2735
  Bottom 0.8: 54.6,99.8 54.6,98
S$2736
  Bottom 0.8: 51.6,102 51.6,103.8
S$2737
  Bottom 0.8: 53.6,102 53.6,103.8
S$2738
  Bottom 0.8: 48.6,99.8 48.6,98
S$2739
  Bottom 0.8: 50.6,99.8 50.6,98
S$2740
  Bottom 0.8: 47.6,102 47.6,103.8
S$2741
  Bottom 0.8: 49.6,102 49.6,103.8
S$2742
  Bottom 0.8: 27.4,91.8 27.4,90
S$2743
  Bottom 0.8: 29.4,91.8 29.4,90
S$2744
  Bottom 0.8: 26.4,94 26.4,95.8
S$2745
  Bottom 0.8: 28.4,94 28.4,95.8
S$2746
  Bottom 0.8: 23.4,91.8 23.4,90
S$2747
  Bottom 0.8: 25.4,91.8 25.4,90
S$2748
  Bottom 0.8: 24.4,94 24.4,95.8
S$2749
  Bottom 0.8: 22.4,94 22.4,95.8
S$2750
  Bottom 0.8: 21.4,91.8 21.4,90
S$2751
  Bottom 0.8: 19.4,91.8 19.4,90
S$2752
  Bottom 0.8: 20.4,94 20.4,95.8
S$2753
  Bottom 0.8: 18.4,94 18.4,95.8
S$2754
  Bottom 0.8: 17.4,91.8 17.4,90
S$2755
  Bottom 0.8: 15.4,91.8 15.4,90
S$2756
  Bottom 0.8: 16.4,94 16.4,95.8
S$2757
  Bottom 0.8: 35.4,91.8 35.4,90
S$2758
  Bottom 0.8: 37.4,91.8 37.4,90
S$2759
  Bottom 0.8: 34.4,94 34.4,95.8
S$2760
  Bottom 0.8: 36.4,94 36.4,95.8
S$2761
  Bottom 0.8: 31.4,91.8 31.4,90
S$2762
  Bottom 0.8: 33.4,91.8 33.4,90
S$2763
  Bottom 0.8: 30.4,94 30.4,95.8
S$2764
  Bottom 0.8: 32.4,94 32.4,95.8
S$2765
  Bottom 0.8: 78.6,99.8 78.6,98
S$2766
  Bottom 0.8: 80.6,99.8 80.6,98
S$2767
  Bottom 0.8: 77.6,102 77.6,103.8
S$2768
  Bottom 0.8: 79.6,102 79.6,103.8
S$2769
  Bottom 0.8: 74.6,99.8 74.6,98
S$2770
  Bottom 0.8: 76.6,99.8 76.6,98
S$2771
  Bottom 0.8: 75.6,102 75.6,103.8
S$2772
  Bottom 0.8: 73.6,102 73.6,103.8
S$2773
  Bottom 0.8: 72.6,99.8 72.6,98
S$2774
  Bottom 0.8: 70.6,99.8 70.6,98
S$2775
  Bottom 0.8: 71.6,102 71.6,103.8
S$2776
  Bottom 0.8: 69.6,102 69.6,103.8
S$2777
  Bottom 0.8: 68.6,99.8 68.6,98
S$2778
  Bottom 0.8: 66.6,99.8 66.6,98
S$2779
  Bottom 0.8: 67.6,102 67.6,103.8
S$2780
  Bottom 0.8: 86.6,99.8 86.6,98
S$2781
  Bottom 0.8: 88.6,99.8 88.6,98
S$2782
  Bottom 0.8: 85.6,102 85.6,103.8
S$2783
  Bottom 0.8: 87.6,102 87.6,103.8
S$2784
  Bottom 0.8: 82.6,99.8 82.6,98
S$2785
  Bottom 0.8: 84.6,99.8 84.6,98
S$2786
  Bottom 0.8: 81.6,102 81.6,103.8
S$2787
  Bottom 0.8: 83.6,102 83.6,103.8
S$2788
  Bottom 0.8: 10.2,99.8 10.2,98
S$2789
  Bottom 0.8: 12.2,99.8 12.2,98
S$2790
  Bottom 0.8: 9.2,102 9.2,103.8
S$2791
  Bottom 0.8: 11.2,102 11.2,103.8
S$2792
  Bottom 0.8: 6.2,99.8 6.2,98
S$2793
  Bottom 0.8: 8.2,99.8 8.2,98
S$2794
  Bottom 0.8: 7.2,102 7.2,103.8
S$2795
  Bottom 0.8: 5.2,102 5.2,103.8
S$2796
  Bottom 0.8: 4.2,99.8 4.2,98
S$2797
  Bottom 0.8: 2.2,99.8 2.2,98
S$2798
  Bottom 0.8: 3.2,102 3.2,103.8
S$2799
  Bottom 0.8: 1.2,102 1.2,103.8
S$2800
  Bottom 0.8: 0.2,99.8 0.2,98
S$2801
  Bottom 0.8: -1.8,99.8 -1.8,98
S$2802
  Bottom 0.8: -0.8,102 -0.8,103.8
S$2803
  Bottom 0.8: 18.2,99.8 18.2,98
S$2804
  Bottom 0.8: 20.2,99.8 20.2,98
S$2805
  Bottom 0.8: 17.2,102 17.2,103.8
S$2806
  Bottom 0.8: 19.2,102 19.2,103.8
S$2807
  Bottom 0.8: 14.2,99.8 14.2,98
S$2808
  Bottom 0.8: 16.2,99.8 16.2,98
S$2809
  Bottom 0.8: 13.2,102 13.2,103.8
S$2810
  Bottom 0.8: 15.2,102 15.2,103.8
S$2811
  Bottom 0.8: 95.8,91.8 95.8,90
S$2812
  Bottom 0.8: 97.8,91.8 97.8,90
S$2813
  Bottom 0.8: 94.8,94 94.8,95.8
S$2814
  Bottom 0.8: 96.8,94 96.8,95.8
S$2815
  Bottom 0.8: 91.8,91.8 91.8,90
S$2816
  Bottom 0.8: 93.8,91.8 93.8,90
S$2817
  Bottom 0.8: 92.8,94 92.8,95.8
S$2818
  Bottom 0.8: 90.8,94 90.8,95.8
S$2819
  Bottom 0.8: 89.8,91.8 89.8,90
S$2820
  Bottom 0.8: 87.8,91.8 87.8,90
S$2821
  Bottom 0.8: 88.8,94 88.8,95.8
S$2822
  Bottom 0.8: 86.8,94 86.8,95.8
S$2823
  Bottom 0.8: 85.8,91.8 85.8,90
S$2824
  Bottom 0.8: 83.8,91.8 83.8,90
S$2825
  Bottom 0.8: 84.8,94 84.8,95.8
S$2826
  Bottom 0.8: 103.8,91.8 103.8,90
S$2827
  Bottom 0.8: 105.8,91.8 105.8,90
S$2828
  Bottom 0.8: 102.8,94 102.8,95.8
S$2829
  Bottom 0.8: 104.8,94 104.8,95.8
S$2830
  Bottom 0.8: 99.8,91.8 99.8,90
S$2831
  Bottom 0.8: 101.8,91.8 101.8,90
S$2832
  Bottom 0.8: 98.8,94 98.8,95.8
S$2833
  Bottom 0.8: 100.8,94 100.8,95.8
S$2834  (via drill 0.2)
  other vias: 1.2,100.9
S$2835  (via drill 0.2)
  other vias: 2.8,100.9
S$2836  (via drill 0.2)
  other vias: 4.4,100.9
S$2837  (via drill 0.2)
  other vias: 6,100.9
S$2838  (via drill 0.2)
  other vias: 7.6,100.9
S$2839  (via drill 0.2)
  other vias: 9.2,100.9
S$2840  (via drill 0.2)
  other vias: 10.8,100.9
S$2841  (via drill 0.2)
  other vias: 12.4,100.9
S$2842  (via drill 0.2)
  other vias: 14,100.9
S$2843  (via drill 0.2)
  other vias: 15.6,100.9
S$2844  (via drill 0.2)
  other vias: 17.2,100.9
S$2845  (via drill 0.2)
  other vias: 2,96.9
S$2846  (via drill 0.2)
  other vias: 3.6,96.9
S$2847  (via drill 0.2)
  other vias: 5.2,96.9
S$2848  (via drill 0.2)
  other vias: 6.8,96.9
S$2849  (via drill 0.2)
  other vias: 8.4,96.9
S$2850  (via drill 0.2)
  other vias: 10,96.9
S$2851  (via drill 0.2)
  other vias: 11.6,96.9
S$2852  (via drill 0.2)
  other vias: 13.2,96.9
S$2853  (via drill 0.2)
  other vias: 14.8,96.9
S$2854  (via drill 0.2)
  other vias: 16.4,96.9
S$2855  (via drill 0.2)
  other vias: 18,92.9
S$2856  (via drill 0.2)
  other vias: 19.6,92.9
S$2857  (via drill 0.2)
  other vias: 21.2,92.9
S$2858  (via drill 0.2)
  other vias: 22.8,92.9
S$2859  (via drill 0.2)
  other vias: 24.4,92.9
S$2860  (via drill 0.2)
  other vias: 18.8,96.9
S$2861  (via drill 0.2)
  other vias: 20.4,96.9
S$2862  (via drill 0.2)
  other vias: 22,96.9
S$2863  (via drill 0.2)
  other vias: 23.6,96.9
S$2864  (via drill 0.2)
  other vias: 25.2,96.9
S$2865  (via drill 0.2)
  other vias: 26,92.9
S$2866  (via drill 0.2)
  other vias: 51.6,100.9
S$2867  (via drill 0.2)
  other vias: 50,100.9
S$2868  (via drill 0.2)
  other vias: 48.4,100.9
S$2869  (via drill 0.2)
  other vias: 46.8,100.9
S$2870  (via drill 0.2)
  other vias: 45.2,100.9
S$2871  (via drill 0.2)
  other vias: 43.6,100.9
S$2872  (via drill 0.2)
  other vias: 42,100.9
S$2873  (via drill 0.2)
  other vias: 40.4,100.9
S$2874  (via drill 0.2)
  other vias: 38.8,100.9
S$2875  (via drill 0.2)
  other vias: 37.2,100.9
S$2876  (via drill 0.2)
  other vias: 35.6,100.9
S$2877  (via drill 0.2)
  other vias: 50.8,96.9
S$2878  (via drill 0.2)
  other vias: 49.2,96.9
S$2879  (via drill 0.2)
  other vias: 47.6,96.9
S$2880  (via drill 0.2)
  other vias: 46,96.9
S$2881  (via drill 0.2)
  other vias: 44.4,96.9
S$2882  (via drill 0.2)
  other vias: 42.8,96.9
S$2883  (via drill 0.2)
  other vias: 41.2,96.9
S$2884  (via drill 0.2)
  other vias: 39.6,96.9
S$2885  (via drill 0.2)
  other vias: 38,96.9
S$2886  (via drill 0.2)
  other vias: 36.4,96.9
S$2887  (via drill 0.2)
  other vias: 34.8,92.9
S$2888  (via drill 0.2)
  other vias: 33.2,92.9
S$2889  (via drill 0.2)
  other vias: 31.6,92.9
S$2890  (via drill 0.2)
  other vias: 30,92.9
S$2891  (via drill 0.2)
  other vias: 28.4,92.9
S$2892  (via drill 0.2)
  other vias: 34,96.9
S$2893  (via drill 0.2)
  other vias: 32.4,96.9
S$2894  (via drill 0.2)
  other vias: 30.8,96.9
S$2895  (via drill 0.2)
  other vias: 29.2,96.9
S$2896  (via drill 0.2)
  other vias: 27.6,96.9
S$2897  (via drill 0.2)
  other vias: 26.8,92.9
S$2898  (via drill 0.2)
  other vias: 52.4,96.9
S$2899  (via drill 0.2)
  other vias: 54,96.9
S$2900  (via drill 0.2)
  other vias: 55.6,96.9
S$2901  (via drill 0.2)
  other vias: 57.2,96.9
S$2902  (via drill 0.2)
  other vias: 58.8,96.9
S$2903  (via drill 0.2)
  other vias: 60.4,96.9
S$2904  (via drill 0.2)
  other vias: 62,96.9
S$2905  (via drill 0.2)
  other vias: 63.6,96.9
S$2906  (via drill 0.2)
  other vias: 65.2,96.9
S$2907  (via drill 0.2)
  other vias: 66.8,96.9
S$2908  (via drill 0.2)
  other vias: 68.4,92.9
S$2909  (via drill 0.2)
  other vias: 53.2,92.9
S$2910  (via drill 0.2)
  other vias: 54.8,92.9
S$2911  (via drill 0.2)
  other vias: 56.4,92.9
S$2912  (via drill 0.2)
  other vias: 58,92.9
S$2913  (via drill 0.2)
  other vias: 59.6,92.9
S$2914  (via drill 0.2)
  other vias: 61.2,92.9
S$2915  (via drill 0.2)
  other vias: 62.8,92.9
S$2916  (via drill 0.2)
  other vias: 64.4,92.9
S$2917  (via drill 0.2)
  other vias: 66,92.9
S$2918  (via drill 0.2)
  other vias: 67.6,92.9
S$2919  (via drill 0.2)
  other vias: 69.2,96.9
S$2920  (via drill 0.2)
  other vias: 70.8,96.9
S$2921  (via drill 0.2)
  other vias: 72.4,96.9
S$2922  (via drill 0.2)
  other vias: 70,100.9
S$2923  (via drill 0.2)
  other vias: 71.6,100.9
S$2924  (via drill 0.2)
  other vias: 73.2,100.9
S$2925  (via drill 0.2)
  other vias: 74,96.9
S$2926  (via drill 0.2)
  other vias: 74.8,100.9
S$2927  (via drill 0.2)
  other vias: 75.6,96.9
S$2928  (via drill 0.2)
  other vias: 76.4,100.9
S$2929  (via drill 0.2)
  other vias: 77.2,96.9
S$2930  (via drill 0.2)
  other vias: 102.8,96.9
S$2931  (via drill 0.2)
  other vias: 101.2,96.9
S$2932  (via drill 0.2)
  other vias: 99.6,96.9
S$2933  (via drill 0.2)
  other vias: 98,96.9
S$2934  (via drill 0.2)
  other vias: 96.4,96.9
S$2935  (via drill 0.2)
  other vias: 94.8,96.9
S$2936  (via drill 0.2)
  other vias: 93.2,96.9
S$2937  (via drill 0.2)
  other vias: 91.6,96.9
S$2938  (via drill 0.2)
  other vias: 90,96.9
S$2939  (via drill 0.2)
  other vias: 88.4,96.9
S$2940  (via drill 0.2)
  other vias: 86.8,92.9
S$2941  (via drill 0.2)
  other vias: 102,92.9
S$2942  (via drill 0.2)
  other vias: 100.4,92.9
S$2943  (via drill 0.2)
  other vias: 98.8,92.9
S$2944  (via drill 0.2)
  other vias: 97.2,92.9
S$2945  (via drill 0.2)
  other vias: 95.6,92.9
S$2946  (via drill 0.2)
  other vias: 94,92.9
S$2947  (via drill 0.2)
  other vias: 92.4,92.9
S$2948  (via drill 0.2)
  other vias: 90.8,92.9
S$2949  (via drill 0.2)
  other vias: 89.2,92.9
S$2950  (via drill 0.2)
  other vias: 87.6,92.9
S$2951  (via drill 0.2)
  other vias: 86,96.9
S$2952  (via drill 0.2)
  other vias: 84.4,96.9
S$2953  (via drill 0.2)
  other vias: 82.8,96.9
S$2954  (via drill 0.2)
  other vias: 85.2,100.9
S$2955  (via drill 0.2)
  other vias: 83.6,100.9
S$2956  (via drill 0.2)
  other vias: 82,100.9
S$2957  (via drill 0.2)
  other vias: 81.2,96.9
S$2958  (via drill 0.2)
  other vias: 80.4,100.9
S$2959  (via drill 0.2)
  other vias: 79.6,96.9
S$2960  (via drill 0.2)
  other vias: 78.8,100.9
S$2961  (via drill 0.2)
  other vias: 78,96.9
S$2962
  Bottom 0.152: -0.8,101.9 0.2,100.9
S$2963
  Bottom 0.152: 0.2,100.9 1.2,100.9
S$2964
  Bottom 0.152: 1.2,101.9 1.8,101.9
S$2965
  Bottom 0.152: 1.8,101.9 2.8,100.9
S$2966
  Bottom 0.152: 3.2,101.9 3.4,101.9
S$2967
  Bottom 0.152: 3.4,101.9 4.4,100.9
S$2968
  Bottom 0.152: 5.2,101.9 6,101.1
S$2969
  Bottom 0.152: 6,101.1 6,100.9
S$2970
  Bottom 0.152: 7.2,101.9 7.6,101.5
S$2971
  Bottom 0.152: 7.6,101.5 7.6,100.9
S$2972
  Bottom 0.152: 9.2,101.9 9.2,100.9
S$2973
  Bottom 0.152: 11.2,101.9 10.8,101.5
S$2974
  Bottom 0.152: 10.8,101.5 10.8,100.9
S$2975
  Bottom 0.152: 13.2,101.9 12.4,101.1
S$2976
  Bottom 0.152: 12.4,101.1 12.4,100.9
S$2977
  Bottom 0.152: 15.2,101.9 15,101.9
S$2978
  Bottom 0.152: 15,101.9 14,100.9
S$2979
  Bottom 0.152: 17.2,101.9 16.6,101.9
S$2980
  Bottom 0.152: 16.6,101.9 15.6,100.9
S$2981
  Bottom 0.152: 19.2,101.9 18.2,100.9
S$2982
  Bottom 0.152: 18.2,100.9 17.2,100.9
S$2983
  Bottom 0.152: 0.2,97.9 1.2,96.9
S$2984
  Bottom 0.152: 1.2,96.9 2,96.9
S$2985
  Bottom 0.152: 2.2,97.9 3.2,96.9
S$2986
  Bottom 0.152: 3.2,96.9 3.6,96.9
S$2987
  Bottom 0.152: 4.2,97.9 5.2,96.9
S$2988
  Bottom 0.152: 6.2,97.9 6.8,97.3
S$2989
  Bottom 0.152: 6.8,97.3 6.8,96.9
S$2990
  Bottom 0.152: 8.2,97.9 8.4,97.7
S$2991
  Bottom 0.152: 8.4,97.7 8.4,96.9
S$2992
  Bottom 0.152: 10.2,97.9 10,97.7
S$2993
  Bottom 0.152: 10,97.7 10,96.9
S$2994
  Bottom 0.152: 12.2,97.9 11.6,97.3
S$2995
  Bottom 0.152: 11.6,97.3 11.6,96.9
S$2996
  Bottom 0.152: 14.2,97.9 13.2,96.9
S$2997
  Bottom 0.152: 16.2,97.9 15.2,96.9
S$2998
  Bottom 0.152: 15.2,96.9 14.8,96.9
S$2999
  Bottom 0.152: 18.2,97.9 17.2,96.9
S$3000
  Bottom 0.152: 17.2,96.9 16.4,96.9
S$3001
  Bottom 0.152: 15.4,91.9 16.4,92.9
S$3002
  Bottom 0.152: 16.4,92.9 18,92.9
S$3003
  Bottom 0.152: 17.4,91.9 18.2,91.9
S$3004
  Bottom 0.152: 18.2,91.9 19.2,92.9
S$3005
  Bottom 0.152: 19.2,92.9 19.6,92.9
S$3006
  Bottom 0.152: 19.4,91.9 20.2,91.9
S$3007
  Bottom 0.152: 20.2,91.9 21.2,92.9
S$3008
  Bottom 0.152: 21.4,91.9 21.8,91.9
S$3009
  Bottom 0.152: 21.8,91.9 22.8,92.9
S$3010
  Bottom 0.152: 23.4,91.9 24.4,92.9
S$3011
  Bottom 0.152: 25.4,91.9 26,92.5
S$3012
  Bottom 0.152: 26,92.5 26,92.9
S$3013
  Bottom 0.152: 16.4,95.9 17,95.9
S$3014
  Bottom 0.152: 17,95.9 18,96.9
S$3015
  Bottom 0.152: 18,96.9 18.8,96.9
S$3016
  Bottom 0.152: 18.4,95.9 19,95.9
S$3017
  Bottom 0.152: 19,95.9 20,96.9
S$3018
  Bottom 0.152: 20,96.9 20.4,96.9
S$3019
  Bottom 0.152: 20.4,95.9 21,95.9
S$3020
  Bottom 0.152: 21,95.9 22,96.9
S$3021
  Bottom 0.152: 22.4,95.9 22.6,95.9
S$3022
  Bottom 0.152: 22.6,95.9 23.6,96.9
S$3023
  Bottom 0.152: 24.4,95.9 25.2,96.7
S$3024
  Bottom 0.152: 25.2,96.7 25.2,96.9
S$3025
  Bottom 0.152: 53.6,101.9 52.6,100.9
S$3026
  Bottom 0.152: 52.6,100.9 51.6,100.9
S$3027
  Bottom 0.152: 51.6,101.9 51,101.9
S$3028
  Bottom 0.152: 51,101.9 50,100.9
S$3029
  Bottom 0.152: 49.6,101.9 49.4,101.9
S$3030
  Bottom 0.152: 49.4,101.9 48.4,100.9
S$3031
  Bottom 0.152: 47.6,101.9 46.8,101.1
S$3032
  Bottom 0.152: 46.8,101.1 46.8,100.9
S$3033
  Bottom 0.152: 45.6,101.9 45.2,101.5
S$3034
  Bottom 0.152: 45.2,101.5 45.2,100.9
S$3035
  Bottom 0.152: 43.6,101.9 43.6,100.9
S$3036
  Bottom 0.152: 41.6,101.9 42,101.5
S$3037
  Bottom 0.152: 42,101.5 42,100.9
S$3038
  Bottom 0.152: 39.6,101.9 40.4,101.1
S$3039
  Bottom 0.152: 40.4,101.1 40.4,100.9
S$3040
  Bottom 0.152: 37.6,101.9 37.8,101.9
S$3041
  Bottom 0.152: 37.8,101.9 38.8,100.9
S$3042
  Bottom 0.152: 35.6,101.9 36.2,101.9
S$3043
  Bottom 0.152: 36.2,101.9 37.2,100.9
S$3044
  Bottom 0.152: 33.6,101.9 34.6,100.9
S$3045
  Bottom 0.152: 34.6,100.9 35.6,100.9
S$3046
  Bottom 0.152: 52.6,97.9 51.6,96.9
S$3047
  Bottom 0.152: 51.6,96.9 50.8,96.9
S$3048
  Bottom 0.152: 50.6,97.9 49.6,96.9
S$3049
  Bottom 0.152: 49.6,96.9 49.2,96.9
S$3050
  Bottom 0.152: 48.6,97.9 47.6,96.9
S$3051
  Bottom 0.152: 46.6,97.9 46,97.3
S$3052
  Bottom 0.152: 46,97.3 46,96.9
S$3053
  Bottom 0.152: 44.6,97.9 44.4,97.7
S$3054
  Bottom 0.152: 44.4,97.7 44.4,96.9
S$3055
  Bottom 0.152: 42.6,97.9 42.8,97.7
S$3056
  Bottom 0.152: 42.8,97.7 42.8,96.9
S$3057
  Bottom 0.152: 40.6,97.9 41.2,97.3
S$3058
  Bottom 0.152: 41.2,97.3 41.2,96.9
S$3059
  Bottom 0.152: 38.6,97.9 39.6,96.9
S$3060
  Bottom 0.152: 36.6,97.9 37.6,96.9
S$3061
  Bottom 0.152: 37.6,96.9 38,96.9
S$3062
  Bottom 0.152: 34.6,97.9 35.6,96.9
S$3063
  Bottom 0.152: 35.6,96.9 36.4,96.9
S$3064
  Bottom 0.152: 37.4,91.9 36.4,92.9
S$3065
  Bottom 0.152: 36.4,92.9 34.8,92.9
S$3066
  Bottom 0.152: 35.4,91.9 34.6,91.9
S$3067
  Bottom 0.152: 34.6,91.9 33.6,92.9
S$3068
  Bottom 0.152: 33.6,92.9 33.2,92.9
S$3069
  Bottom 0.152: 33.4,91.9 32.6,91.9
S$3070
  Bottom 0.152: 32.6,91.9 31.6,92.9
S$3071
  Bottom 0.152: 31.4,91.9 31,91.9
S$3072
  Bottom 0.152: 31,91.9 30,92.9
S$3073
  Bottom 0.152: 29.4,91.9 28.4,92.9
S$3074
  Bottom 0.152: 27.4,91.9 26.8,92.5
S$3075
  Bottom 0.152: 26.8,92.5 26.8,92.9
S$3076
  Bottom 0.152: 36.4,95.9 35.8,95.9
S$3077
  Bottom 0.152: 35.8,95.9 34.8,96.9
S$3078
  Bottom 0.152: 34.8,96.9 34,96.9
S$3079
  Bottom 0.152: 34.4,95.9 33.8,95.9
S$3080
  Bottom 0.152: 33.8,95.9 32.8,96.9
S$3081
  Bottom 0.152: 32.8,96.9 32.4,96.9
S$3082
  Bottom 0.152: 32.4,95.9 31.8,95.9
S$3083
  Bottom 0.152: 31.8,95.9 30.8,96.9
S$3084
  Bottom 0.152: 30.4,95.9 30.2,95.9
S$3085
  Bottom 0.152: 30.2,95.9 29.2,96.9
S$3086
  Bottom 0.152: 28.4,95.9 27.6,96.7
S$3087
  Bottom 0.152: 27.6,96.7 27.6,96.9
S$3088
  Bottom 0.152: 52.4,95.9 53,95.9
S$3089
  Bottom 0.152: 53,95.9 54,96.9
S$3090
  Bottom 0.152: 54.4,95.9 54.6,95.9
S$3091
  Bottom 0.152: 54.6,95.9 55.6,96.9
S$3092
  Bottom 0.152: 56.4,95.9 57.2,96.7
S$3093
  Bottom 0.152: 57.2,96.7 57.2,96.9
S$3094
  Bottom 0.152: 58.4,95.9 58.8,96.3
S$3095
  Bottom 0.152: 58.8,96.3 58.8,96.9
S$3096
  Bottom 0.152: 60.4,95.9 60.4,96.9
S$3097
  Bottom 0.152: 50.4,95.9 51.4,95.9
S$3098
  Bottom 0.152: 51.4,95.9 52.4,96.9
S$3099
  Bottom 0.152: 51.4,91.9 52.4,92.9
S$3100
  Bottom 0.152: 52.4,92.9 53.2,92.9
S$3101
  Bottom 0.152: 53.4,91.9 53.8,91.9
S$3102
  Bottom 0.152: 53.8,91.9 54.8,92.9
S$3103
  Bottom 0.152: 55.4,91.9 56.4,92.9
S$3104
  Bottom 0.152: 57.4,91.9 58,92.5
S$3105
  Bottom 0.152: 58,92.5 58,92.9
S$3106
  Bottom 0.152: 59.4,91.9 59.6,92.1
S$3107
  Bottom 0.152: 59.6,92.1 59.6,92.9
S$3108
  Bottom 0.152: 61.4,91.9 61.2,92.1
S$3109
  Bottom 0.152: 61.2,92.1 61.2,92.9
S$3110
  Bottom 0.152: 63.4,91.9 62.8,92.5
S$3111
  Bottom 0.152: 62.8,92.5 62.8,92.9
S$3112
  Bottom 0.152: 65.4,91.9 64.4,92.9
S$3113
  Bottom 0.152: 67.4,91.9 67,91.9
S$3114
  Bottom 0.152: 67,91.9 66,92.9
S$3115
  Bottom 0.152: 69.4,91.9 68.6,91.9
S$3116
  Bottom 0.152: 68.6,91.9 67.6,92.9
S$3117
  Bottom 0.152: 62.4,95.9 62,96.3
S$3118
  Bottom 0.152: 62,96.3 62,96.9
S$3119
  Bottom 0.152: 64.4,95.9 63.6,96.7
S$3120
  Bottom 0.152: 63.6,96.7 63.6,96.9
S$3121
  Bottom 0.152: 66.4,95.9 66.2,95.9
S$3122
  Bottom 0.152: 66.2,95.9 65.2,96.9
S$3123
  Bottom 0.152: 68.4,95.9 67.8,95.9
S$3124
  Bottom 0.152: 67.8,95.9 66.8,96.9
S$3125
  Bottom 0.152: 70.4,93.9 69.4,92.9
S$3126
  Bottom 0.152: 69.4,92.9 68.4,92.9
S$3127
  Bottom 0.152: 68.6,97.9 69.2,97.9
S$3128
  Bottom 0.152: 69.2,97.9 70.2,96.9
S$3129
  Bottom 0.152: 70.2,96.9 70.8,96.9
S$3130
  Bottom 0.152: 70.6,97.9 71.6,96.9
S$3131
  Bottom 0.152: 71.6,96.9 72.4,96.9
S$3132
  Bottom 0.152: 72.6,97.9 73.6,96.9
S$3133
  Bottom 0.152: 73.6,96.9 74,96.9
S$3134
  Bottom 0.152: 74.6,97.9 75.6,96.9
S$3135
  Bottom 0.152: 76.6,97.9 77.2,97.3
S$3136
  Bottom 0.152: 77.2,97.3 77.2,96.9
S$3137
  Bottom 0.152: 67.6,101.9 68.6,100.9
S$3138
  Bottom 0.152: 68.6,100.9 70,100.9
S$3139
  Bottom 0.152: 69.6,101.9 70,101.9
S$3140
  Bottom 0.152: 70,101.9 71,100.9
S$3141
  Bottom 0.152: 71,100.9 71.6,100.9
S$3142
  Bottom 0.152: 71.6,101.9 72.2,101.9
S$3143
  Bottom 0.152: 72.2,101.9 73.2,100.9
S$3144
  Bottom 0.152: 73.6,101.9 73.8,101.9
S$3145
  Bottom 0.152: 73.8,101.9 74.8,100.9
S$3146
  Bottom 0.152: 75.6,101.9 76.4,101.1
S$3147
  Bottom 0.152: 76.4,101.1 76.4,100.9
S$3148
  Bottom 0.152: 69.2,96.9 68,96.9
S$3149
  Bottom 0.152: 68,96.9 67,97.9
S$3150
  Bottom 0.152: 67,97.9 66.6,97.9
S$3151
  Bottom 0.152: 102.8,95.9 102.2,95.9
S$3152
  Bottom 0.152: 102.2,95.9 101.2,96.9
S$3153
  Bottom 0.152: 100.8,95.9 100.6,95.9
S$3154
  Bottom 0.152: 100.6,95.9 99.6,96.9
S$3155
  Bottom 0.152: 98.8,95.9 98,96.7
S$3156
  Bottom 0.152: 98,96.7 98,96.9
S$3157
  Bottom 0.152: 96.8,95.9 96.4,96.3
S$3158
  Bottom 0.152: 96.4,96.3 96.4,96.9
S$3159
  Bottom 0.152: 94.8,95.9 94.8,96.9
S$3160
  Bottom 0.152: 104.8,95.9 103.8,95.9
S$3161
  Bottom 0.152: 103.8,95.9 102.8,96.9
S$3162
  Bottom 0.152: 103.8,91.9 102.8,92.9
S$3163
  Bottom 0.152: 102.8,92.9 102,92.9
S$3164
  Bottom 0.152: 101.8,91.9 101.4,91.9
S$3165
  Bottom 0.152: 101.4,91.9 100.4,92.9
S$3166
  Bottom 0.152: 99.8,91.9 98.8,92.9
S$3167
  Bottom 0.152: 97.8,91.9 97.2,92.5
S$3168
  Bottom 0.152: 97.2,92.5 97.2,92.9
S$3169
  Bottom 0.152: 95.8,91.9 95.6,92.1
S$3170
  Bottom 0.152: 95.6,92.1 95.6,92.9
S$3171
  Bottom 0.152: 93.8,91.9 94,92.1
S$3172
  Bottom 0.152: 94,92.1 94,92.9
S$3173
  Bottom 0.152: 91.8,91.9 92.4,92.5
S$3174
  Bottom 0.152: 92.4,92.5 92.4,92.9
S$3175
  Bottom 0.152: 89.8,91.9 90.8,92.9
S$3176
  Bottom 0.152: 87.8,91.9 88.2,91.9
S$3177
  Bottom 0.152: 88.2,91.9 89.2,92.9
S$3178
  Bottom 0.152: 85.8,91.9 86.6,91.9
S$3179
  Bottom 0.152: 86.6,91.9 87.6,92.9
S$3180
  Bottom 0.152: 92.8,95.9 93.2,96.3
S$3181
  Bottom 0.152: 93.2,96.3 93.2,96.9
S$3182
  Bottom 0.152: 90.8,95.9 91.6,96.7
S$3183
  Bottom 0.152: 91.6,96.7 91.6,96.9
S$3184
  Bottom 0.152: 88.8,95.9 89,95.9
S$3185
  Bottom 0.152: 89,95.9 90,96.9
S$3186
  Bottom 0.152: 86.8,95.9 87.4,95.9
S$3187
  Bottom 0.152: 87.4,95.9 88.4,96.9
S$3188
  Bottom 0.152: 84.8,93.9 85.8,92.9
S$3189
  Bottom 0.152: 85.8,92.9 86.8,92.9
S$3190
  Bottom 0.152: 86.6,97.9 86,97.9
S$3191
  Bottom 0.152: 86,97.9 85,96.9
S$3192
  Bottom 0.152: 85,96.9 84.4,96.9
S$3193
  Bottom 0.152: 84.6,97.9 83.6,96.9
S$3194
  Bottom 0.152: 83.6,96.9 82.8,96.9
S$3195
  Bottom 0.152: 82.6,97.9 81.6,96.9
S$3196
  Bottom 0.152: 81.6,96.9 81.2,96.9
S$3197
  Bottom 0.152: 80.6,97.9 79.6,96.9
S$3198
  Bottom 0.152: 78.6,97.9 78,97.3
S$3199
  Bottom 0.152: 78,97.3 78,96.9
S$3200
  Bottom 0.152: 87.6,101.9 86.6,100.9
S$3201
  Bottom 0.152: 86.6,100.9 85.2,100.9
S$3202
  Bottom 0.152: 85.6,101.9 85.2,101.9
S$3203
  Bottom 0.152: 85.2,101.9 84.2,100.9
S$3204
  Bottom 0.152: 84.2,100.9 83.6,100.9
S$3205
  Bottom 0.152: 83.6,101.9 83,101.9
S$3206
  Bottom 0.152: 83,101.9 82,100.9
S$3207
  Bottom 0.152: 81.6,101.9 81.4,101.9
S$3208
  Bottom 0.152: 81.4,101.9 80.4,100.9
S$3209
  Bottom 0.152: 79.6,101.9 78.8,101.1
S$3210
  Bottom 0.152: 78.8,101.1 78.8,100.9
S$3211
  Bottom 0.152: 86,96.9 87.2,96.9
S$3212
  Bottom 0.152: 87.2,96.9 88.2,97.9
S$3213
  Bottom 0.152: 88.2,97.9 88.6,97.9
S$3214  (2 unrouted)
  Top 0.813: 117,101.4 117,92.4
  Top 1.8: 118,98.4 116,98.4 | 118,101.4 117,101.4 116,101.4 | 118,95.4 116,95.4 | 118,92.4 117,92.4 116,92.4
S$3215
  Top 1.778: -52.08,93.73 -52.08,95.25
S$3216
  Top 1.778: -52.08,98.55 -52.08,100.08
S$3217
  Top 1.778: -47,93.73 -47,95.25
S$3218
  Top 1.778: -47,98.55 -47,100.08
S$3219
  Top 1.778: -41.92,93.73 -41.92,95.25
S$3220
  Top 1.778: -41.92,98.55 -41.92,100.08
S$3221
  Top 1.778: 145.92,93.73 145.92,95.25
S$3222
  Top 1.778: 145.92,98.55 145.92,100.08
S$3223
  Top 1.778: 151,93.73 151,95.25
S$3224
  Top 1.778: 151,98.55 151,100.08
S$3225
  Top 1.778: 156.08,93.73 156.08,95.25
S$3226
  Top 1.778: 156.08,98.55 156.08,100.08
S$3227  (via drill 0.2)
  other vias: 26.4,103.3
S$3228  (via drill 0.2)
  other vias: 43.4,90.5
S$3229  (via drill 0.2)
  other vias: 60.6,103.3
S$3230  (via drill 0.2)
  other vias: 77.6,90.5
S$3231  (via drill 0.2)
  other vias: 93.6,103.3
S$3232  (via drill 0.2)
  other vias: 104.8,103.3
S$3233  (via drill 0.2)
  other vias: 10.4,90.5
S$3234  (via drill 0.2)
  other vias: -0.8,90.5
S$3235
  Bottom 0.8: 61.4,109.8 61.4,108
S$3236
  Bottom 0.8: 63.4,109.8 63.4,108
S$3237
  Bottom 0.8: 60.4,112 60.4,113.8
S$3238
  Bottom 0.8: 62.4,112 62.4,113.8
S$3239
  Bottom 0.8: 57.4,109.8 57.4,108
S$3240
  Bottom 0.8: 59.4,109.8 59.4,108
S$3241
  Bottom 0.8: 58.4,112 58.4,113.8
S$3242
  Bottom 0.8: 56.4,112 56.4,113.8
S$3243
  Bottom 0.8: 55.4,109.8 55.4,108
S$3244
  Bottom 0.8: 53.4,109.8 53.4,108
S$3245
  Bottom 0.8: 54.4,112 54.4,113.8
S$3246
  Bottom 0.8: 52.4,112 52.4,113.8
S$3247
  Bottom 0.8: 51.4,109.8 51.4,108
S$3248
  Bottom 0.8: 49.4,109.8 49.4,108
S$3249
  Bottom 0.8: 50.4,112 50.4,113.8
S$3250
  Bottom 0.8: 69.4,109.8 69.4,108
S$3251
  Bottom 0.8: 71.4,109.8 71.4,108
S$3252
  Bottom 0.8: 68.4,112 68.4,113.8
S$3253
  Bottom 0.8: 70.4,112 70.4,113.8
S$3254
  Bottom 0.8: 65.4,109.8 65.4,108
S$3255
  Bottom 0.8: 67.4,109.8 67.4,108
S$3256
  Bottom 0.8: 64.4,112 64.4,113.8
S$3257
  Bottom 0.8: 66.4,112 66.4,113.8
S$3258
  Bottom 0.8: 44.6,117.8 44.6,116
S$3259
  Bottom 0.8: 46.6,117.8 46.6,116
S$3260
  Bottom 0.8: 43.6,120 43.6,121.8
S$3261
  Bottom 0.8: 45.6,120 45.6,121.8
S$3262
  Bottom 0.8: 40.6,117.8 40.6,116
S$3263
  Bottom 0.8: 42.6,117.8 42.6,116
S$3264
  Bottom 0.8: 41.6,120 41.6,121.8
S$3265
  Bottom 0.8: 39.6,120 39.6,121.8
S$3266
  Bottom 0.8: 38.6,117.8 38.6,116
S$3267
  Bottom 0.8: 36.6,117.8 36.6,116
S$3268
  Bottom 0.8: 37.6,120 37.6,121.8
S$3269
  Bottom 0.8: 35.6,120 35.6,121.8
S$3270
  Bottom 0.8: 34.6,117.8 34.6,116
S$3271
  Bottom 0.8: 32.6,117.8 32.6,116
S$3272
  Bottom 0.8: 33.6,120 33.6,121.8
S$3273
  Bottom 0.8: 52.6,117.8 52.6,116
S$3274
  Bottom 0.8: 54.6,117.8 54.6,116
S$3275
  Bottom 0.8: 51.6,120 51.6,121.8
S$3276
  Bottom 0.8: 53.6,120 53.6,121.8
S$3277
  Bottom 0.8: 48.6,117.8 48.6,116
S$3278
  Bottom 0.8: 50.6,117.8 50.6,116
S$3279
  Bottom 0.8: 47.6,120 47.6,121.8
S$3280
  Bottom 0.8: 49.6,120 49.6,121.8
S$3281
  Bottom 0.8: 27.4,109.8 27.4,108
S$3282
  Bottom 0.8: 29.4,109.8 29.4,108
S$3283
  Bottom 0.8: 26.4,112 26.4,113.8
S$3284
  Bottom 0.8: 28.4,112 28.4,113.8
S$3285
  Bottom 0.8: 23.4,109.8 23.4,108
S$3286
  Bottom 0.8: 25.4,109.8 25.4,108
S$3287
  Bottom 0.8: 24.4,112 24.4,113.8
S$3288
  Bottom 0.8: 22.4,112 22.4,113.8
S$3289
  Bottom 0.8: 21.4,109.8 21.4,108
S$3290
  Bottom 0.8: 19.4,109.8 19.4,108
S$3291
  Bottom 0.8: 20.4,112 20.4,113.8
S$3292
  Bottom 0.8: 18.4,112 18.4,113.8
S$3293
  Bottom 0.8: 17.4,109.8 17.4,108
S$3294
  Bottom 0.8: 15.4,109.8 15.4,108
S$3295
  Bottom 0.8: 16.4,112 16.4,113.8
S$3296
  Bottom 0.8: 35.4,109.8 35.4,108
S$3297
  Bottom 0.8: 37.4,109.8 37.4,108
S$3298
  Bottom 0.8: 34.4,112 34.4,113.8
S$3299
  Bottom 0.8: 36.4,112 36.4,113.8
S$3300
  Bottom 0.8: 31.4,109.8 31.4,108
S$3301
  Bottom 0.8: 33.4,109.8 33.4,108
S$3302
  Bottom 0.8: 30.4,112 30.4,113.8
S$3303
  Bottom 0.8: 32.4,112 32.4,113.8
S$3304
  Bottom 0.8: 78.6,117.8 78.6,116
S$3305
  Bottom 0.8: 80.6,117.8 80.6,116
S$3306
  Bottom 0.8: 77.6,120 77.6,121.8
S$3307
  Bottom 0.8: 79.6,120 79.6,121.8
S$3308
  Bottom 0.8: 74.6,117.8 74.6,116
S$3309
  Bottom 0.8: 76.6,117.8 76.6,116
S$3310
  Bottom 0.8: 75.6,120 75.6,121.8
S$3311
  Bottom 0.8: 73.6,120 73.6,121.8
S$3312
  Bottom 0.8: 72.6,117.8 72.6,116
S$3313
  Bottom 0.8: 70.6,117.8 70.6,116
S$3314
  Bottom 0.8: 71.6,120 71.6,121.8
S$3315
  Bottom 0.8: 69.6,120 69.6,121.8
S$3316
  Bottom 0.8: 68.6,117.8 68.6,116
S$3317
  Bottom 0.8: 66.6,117.8 66.6,116
S$3318
  Bottom 0.8: 67.6,120 67.6,121.8
S$3319
  Bottom 0.8: 86.6,117.8 86.6,116
S$3320
  Bottom 0.8: 88.6,117.8 88.6,116
S$3321
  Bottom 0.8: 85.6,120 85.6,121.8
S$3322
  Bottom 0.8: 87.6,120 87.6,121.8
S$3323
  Bottom 0.8: 82.6,117.8 82.6,116
S$3324
  Bottom 0.8: 84.6,117.8 84.6,116
S$3325
  Bottom 0.8: 81.6,120 81.6,121.8
S$3326
  Bottom 0.8: 83.6,120 83.6,121.8
S$3327
  Bottom 0.8: 10.2,117.8 10.2,116
S$3328
  Bottom 0.8: 12.2,117.8 12.2,116
S$3329
  Bottom 0.8: 9.2,120 9.2,121.8
S$3330
  Bottom 0.8: 11.2,120 11.2,121.8
S$3331
  Bottom 0.8: 6.2,117.8 6.2,116
S$3332
  Bottom 0.8: 8.2,117.8 8.2,116
S$3333
  Bottom 0.8: 7.2,120 7.2,121.8
S$3334
  Bottom 0.8: 5.2,120 5.2,121.8
S$3335
  Bottom 0.8: 4.2,117.8 4.2,116
S$3336
  Bottom 0.8: 2.2,117.8 2.2,116
S$3337
  Bottom 0.8: 3.2,120 3.2,121.8
S$3338
  Bottom 0.8: 1.2,120 1.2,121.8
S$3339
  Bottom 0.8: 0.2,117.8 0.2,116
S$3340
  Bottom 0.8: -1.8,117.8 -1.8,116
S$3341
  Bottom 0.8: -0.8,120 -0.8,121.8
S$3342
  Bottom 0.8: 18.2,117.8 18.2,116
S$3343
  Bottom 0.8: 20.2,117.8 20.2,116
S$3344
  Bottom 0.8: 17.2,120 17.2,121.8
S$3345
  Bottom 0.8: 19.2,120 19.2,121.8
S$3346
  Bottom 0.8: 14.2,117.8 14.2,116
S$3347
  Bottom 0.8: 16.2,117.8 16.2,116
S$3348
  Bottom 0.8: 13.2,120 13.2,121.8
S$3349
  Bottom 0.8: 15.2,120 15.2,121.8
S$3350
  Bottom 0.8: 95.8,109.8 95.8,108
S$3351
  Bottom 0.8: 97.8,109.8 97.8,108
S$3352
  Bottom 0.8: 94.8,112 94.8,113.8
S$3353
  Bottom 0.8: 96.8,112 96.8,113.8
S$3354
  Bottom 0.8: 91.8,109.8 91.8,108
S$3355
  Bottom 0.8: 93.8,109.8 93.8,108
S$3356
  Bottom 0.8: 92.8,112 92.8,113.8
S$3357
  Bottom 0.8: 90.8,112 90.8,113.8
S$3358
  Bottom 0.8: 89.8,109.8 89.8,108
S$3359
  Bottom 0.8: 87.8,109.8 87.8,108
S$3360
  Bottom 0.8: 88.8,112 88.8,113.8
S$3361
  Bottom 0.8: 86.8,112 86.8,113.8
S$3362
  Bottom 0.8: 85.8,109.8 85.8,108
S$3363
  Bottom 0.8: 83.8,109.8 83.8,108
S$3364
  Bottom 0.8: 84.8,112 84.8,113.8
S$3365
  Bottom 0.8: 103.8,109.8 103.8,108
S$3366
  Bottom 0.8: 105.8,109.8 105.8,108
S$3367
  Bottom 0.8: 102.8,112 102.8,113.8
S$3368
  Bottom 0.8: 104.8,112 104.8,113.8
S$3369
  Bottom 0.8: 99.8,109.8 99.8,108
S$3370
  Bottom 0.8: 101.8,109.8 101.8,108
S$3371
  Bottom 0.8: 98.8,112 98.8,113.8
S$3372
  Bottom 0.8: 100.8,112 100.8,113.8
S$3373  (via drill 0.2)
  other vias: 1.2,118.9
S$3374  (via drill 0.2)
  other vias: 2.8,118.9
S$3375  (via drill 0.2)
  other vias: 4.4,118.9
S$3376  (via drill 0.2)
  other vias: 6,118.9
S$3377  (via drill 0.2)
  other vias: 7.6,118.9
S$3378  (via drill 0.2)
  other vias: 9.2,118.9
S$3379  (via drill 0.2)
  other vias: 10.8,118.9
S$3380  (via drill 0.2)
  other vias: 12.4,118.9
S$3381  (via drill 0.2)
  other vias: 14,118.9
S$3382  (via drill 0.2)
  other vias: 15.6,118.9
S$3383  (via drill 0.2)
  other vias: 17.2,118.9
S$3384  (via drill 0.2)
  other vias: 2,114.9
S$3385  (via drill 0.2)
  other vias: 3.6,114.9
S$3386  (via drill 0.2)
  other vias: 5.2,114.9
S$3387  (via drill 0.2)
  other vias: 6.8,114.9
S$3388  (via drill 0.2)
  other vias: 8.4,114.9
S$3389  (via drill 0.2)
  other vias: 10,114.9
S$3390  (via drill 0.2)
  other vias: 11.6,114.9
S$3391  (via drill 0.2)
  other vias: 13.2,114.9
S$3392  (via drill 0.2)
  other vias: 14.8,114.9
S$3393  (via drill 0.2)
  other vias: 16.4,114.9
S$3394  (via drill 0.2)
  other vias: 18,110.9
S$3395  (via drill 0.2)
  other vias: 19.6,110.9
S$3396  (via drill 0.2)
  other vias: 21.2,110.9
S$3397  (via drill 0.2)
  other vias: 22.8,110.9
S$3398  (via drill 0.2)
  other vias: 24.4,110.9
S$3399  (via drill 0.2)
  other vias: 18.8,114.9
S$3400  (via drill 0.2)
  other vias: 20.4,114.9
S$3401  (via drill 0.2)
  other vias: 22,114.9
S$3402  (via drill 0.2)
  other vias: 23.6,114.9
S$3403  (via drill 0.2)
  other vias: 25.2,114.9
S$3404  (via drill 0.2)
  other vias: 26,110.9
S$3405  (via drill 0.2)
  other vias: 51.6,118.9
S$3406  (via drill 0.2)
  other vias: 50,118.9
S$3407  (via drill 0.2)
  other vias: 48.4,118.9
S$3408  (via drill 0.2)
  other vias: 46.8,118.9
S$3409  (via drill 0.2)
  other vias: 45.2,118.9
S$3410  (via drill 0.2)
  other vias: 43.6,118.9
S$3411  (via drill 0.2)
  other vias: 42,118.9
S$3412  (via drill 0.2)
  other vias: 40.4,118.9
S$3413  (via drill 0.2)
  other vias: 38.8,118.9
S$3414  (via drill 0.2)
  other vias: 37.2,118.9
S$3415  (via drill 0.2)
  other vias: 35.6,118.9
S$3416  (via drill 0.2)
  other vias: 50.8,114.9
S$3417  (via drill 0.2)
  other vias: 49.2,114.9
S$3418  (via drill 0.2)
  other vias: 47.6,114.9
S$3419  (via drill 0.2)
  other vias: 46,114.9
S$3420  (via drill 0.2)
  other vias: 44.4,114.9
S$3421  (via drill 0.2)
  other vias: 42.8,114.9
S$3422  (via drill 0.2)
  other vias: 41.2,114.9
S$3423  (via drill 0.2)
  other vias: 39.6,114.9
S$3424  (via drill 0.2)
  other vias: 38,114.9
S$3425  (via drill 0.2)
  other vias: 36.4,114.9
S$3426  (via drill 0.2)
  other vias: 34.8,110.9
S$3427  (via drill 0.2)
  other vias: 33.2,110.9
S$3428  (via drill 0.2)
  other vias: 31.6,110.9
S$3429  (via drill 0.2)
  other vias: 30,110.9
S$3430  (via drill 0.2)
  other vias: 28.4,110.9
S$3431  (via drill 0.2)
  other vias: 34,114.9
S$3432  (via drill 0.2)
  other vias: 32.4,114.9
S$3433  (via drill 0.2)
  other vias: 30.8,114.9
S$3434  (via drill 0.2)
  other vias: 29.2,114.9
S$3435  (via drill 0.2)
  other vias: 27.6,114.9
S$3436  (via drill 0.2)
  other vias: 26.8,110.9
S$3437  (via drill 0.2)
  other vias: 52.4,114.9
S$3438  (via drill 0.2)
  other vias: 54,114.9
S$3439  (via drill 0.2)
  other vias: 55.6,114.9
S$3440  (via drill 0.2)
  other vias: 57.2,114.9
S$3441  (via drill 0.2)
  other vias: 58.8,114.9
S$3442  (via drill 0.2)
  other vias: 60.4,114.9
S$3443  (via drill 0.2)
  other vias: 62,114.9
S$3444  (via drill 0.2)
  other vias: 63.6,114.9
S$3445  (via drill 0.2)
  other vias: 65.2,114.9
S$3446  (via drill 0.2)
  other vias: 66.8,114.9
S$3447  (via drill 0.2)
  other vias: 68.4,110.9
S$3448  (via drill 0.2)
  other vias: 53.2,110.9
S$3449  (via drill 0.2)
  other vias: 54.8,110.9
S$3450  (via drill 0.2)
  other vias: 56.4,110.9
S$3451  (via drill 0.2)
  other vias: 58,110.9
S$3452  (via drill 0.2)
  other vias: 59.6,110.9
S$3453  (via drill 0.2)
  other vias: 61.2,110.9
S$3454  (via drill 0.2)
  other vias: 62.8,110.9
S$3455  (via drill 0.2)
  other vias: 64.4,110.9
S$3456  (via drill 0.2)
  other vias: 66,110.9
S$3457  (via drill 0.2)
  other vias: 67.6,110.9
S$3458  (via drill 0.2)
  other vias: 69.2,114.9
S$3459  (via drill 0.2)
  other vias: 70.8,114.9
S$3460  (via drill 0.2)
  other vias: 72.4,114.9
S$3461  (via drill 0.2)
  other vias: 70,118.9
S$3462  (via drill 0.2)
  other vias: 71.6,118.9
S$3463  (via drill 0.2)
  other vias: 73.2,118.9
S$3464  (via drill 0.2)
  other vias: 74,114.9
S$3465  (via drill 0.2)
  other vias: 74.8,118.9
S$3466  (via drill 0.2)