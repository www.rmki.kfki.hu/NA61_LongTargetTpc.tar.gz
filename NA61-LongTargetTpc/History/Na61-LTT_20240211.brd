# EAGLE board Na61-LTT_20240211 (EAGLE 9.6.2), part 2 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$1173 (continued)
  Bottom 0.8: 9.2,48 9.2,49.8
S$1174
  Bottom 0.8: 11.2,48 11.2,49.8
S$1175
  Bottom 0.8: 6.2,45.8 6.2,44
S$1176
  Bottom 0.8: 8.2,45.8 8.2,44
S$1177
  Bottom 0.8: 7.2,48 7.2,49.8
S$1178
  Bottom 0.8: 5.2,48 5.2,49.8
S$1179
  Bottom 0.8: 4.2,45.8 4.2,44
S$1180
  Bottom 0.8: 2.2,45.8 2.2,44
S$1181
  Bottom 0.8: 3.2,48 3.2,49.8
S$1182
  Bottom 0.8: 1.2,48 1.2,49.8
S$1183
  Bottom 0.8: 0.2,45.8 0.2,44
S$1184
  Bottom 0.8: -1.8,45.8 -1.8,44
S$1185
  Bottom 0.8: -0.8,48 -0.8,49.8
S$1186
  Bottom 0.8: 18.2,45.8 18.2,44
S$1187
  Bottom 0.8: 20.2,45.8 20.2,44
S$1188
  Bottom 0.8: 17.2,48 17.2,49.8
S$1189
  Bottom 0.8: 19.2,48 19.2,49.8
S$1190
  Bottom 0.8: 14.2,45.8 14.2,44
S$1191
  Bottom 0.8: 16.2,45.8 16.2,44
S$1192
  Bottom 0.8: 13.2,48 13.2,49.8
S$1193
  Bottom 0.8: 15.2,48 15.2,49.8
S$1194
  Bottom 0.8: 95.8,37.8 95.8,36
S$1195
  Bottom 0.8: 97.8,37.8 97.8,36
S$1196
  Bottom 0.8: 94.8,40 94.8,41.8
S$1197
  Bottom 0.8: 96.8,40 96.8,41.8
S$1198
  Bottom 0.8: 91.8,37.8 91.8,36
S$1199
  Bottom 0.8: 93.8,37.8 93.8,36
S$1200
  Bottom 0.8: 92.8,40 92.8,41.8
S$1201
  Bottom 0.8: 90.8,40 90.8,41.8
S$1202
  Bottom 0.8: 89.8,37.8 89.8,36
S$1203
  Bottom 0.8: 87.8,37.8 87.8,36
S$1204
  Bottom 0.8: 88.8,40 88.8,41.8
S$1205
  Bottom 0.8: 86.8,40 86.8,41.8
S$1206
  Bottom 0.8: 85.8,37.8 85.8,36
S$1207
  Bottom 0.8: 83.8,37.8 83.8,36
S$1208
  Bottom 0.8: 84.8,40 84.8,41.8
S$1209
  Bottom 0.8: 103.8,37.8 103.8,36
S$1210
  Bottom 0.8: 105.8,37.8 105.8,36
S$1211
  Bottom 0.8: 102.8,40 102.8,41.8
S$1212
  Bottom 0.8: 104.8,40 104.8,41.8
S$1213
  Bottom 0.8: 99.8,37.8 99.8,36
S$1214
  Bottom 0.8: 101.8,37.8 101.8,36
S$1215
  Bottom 0.8: 98.8,40 98.8,41.8
S$1216
  Bottom 0.8: 100.8,40 100.8,41.8
S$1217  (via drill 0.2)
  other vias: 1.2,46.9
S$1218  (via drill 0.2)
  other vias: 2.8,46.9
S$1219  (via drill 0.2)
  other vias: 4.4,46.9
S$1220  (via drill 0.2)
  other vias: 6,46.9
S$1221  (via drill 0.2)
  other vias: 7.6,46.9
S$1222  (via drill 0.2)
  other vias: 9.2,46.9
S$1223  (via drill 0.2)
  other vias: 10.8,46.9
S$1224  (via drill 0.2)
  other vias: 12.4,46.9
S$1225  (via drill 0.2)
  other vias: 14,46.9
S$1226  (via drill 0.2)
  other vias: 15.6,46.9
S$1227  (via drill 0.2)
  other vias: 17.2,46.9
S$1228  (via drill 0.2)
  other vias: 2,42.9
S$1229  (via drill 0.2)
  other vias: 3.6,42.9
S$1230  (via drill 0.2)
  other vias: 5.2,42.9
S$1231  (via drill 0.2)
  other vias: 6.8,42.9
S$1232  (via drill 0.2)
  other vias: 8.4,42.9
S$1233  (via drill 0.2)
  other vias: 10,42.9
S$1234  (via drill 0.2)
  other vias: 11.6,42.9
S$1235  (via drill 0.2)
  other vias: 13.2,42.9
S$1236  (via drill 0.2)
  other vias: 14.8,42.9
S$1237  (via drill 0.2)
  other vias: 16.4,42.9
S$1238  (via drill 0.2)
  other vias: 18,38.9
S$1239  (via drill 0.2)
  other vias: 19.6,38.9
S$1240  (via drill 0.2)
  other vias: 21.2,38.9
S$1241  (via drill 0.2)
  other vias: 22.8,38.9
S$1242  (via drill 0.2)
  other vias: 24.4,38.9
S$1243  (via drill 0.2)
  other vias: 18.8,42.9
S$1244  (via drill 0.2)
  other vias: 20.4,42.9
S$1245  (via drill 0.2)
  other vias: 22,42.9
S$1246  (via drill 0.2)
  other vias: 23.6,42.9
S$1247  (via drill 0.2)
  other vias: 25.2,42.9
S$1248  (via drill 0.2)
  other vias: 26,38.9
S$1249  (via drill 0.2)
  other vias: 51.6,46.9
S$1250  (via drill 0.2)
  other vias: 50,46.9
S$1251  (via drill 0.2)
  other vias: 48.4,46.9
S$1252  (via drill 0.2)
  other vias: 46.8,46.9
S$1253  (via drill 0.2)
  other vias: 45.2,46.9
S$1254  (via drill 0.2)
  other vias: 43.6,46.9
S$1255  (via drill 0.2)
  other vias: 42,46.9
S$1256  (via drill 0.2)
  other vias: 40.4,46.9
S$1257  (via drill 0.2)
  other vias: 38.8,46.9
S$1258  (via drill 0.2)
  other vias: 37.2,46.9
S$1259  (via drill 0.2)
  other vias: 35.6,46.9
S$1260  (via drill 0.2)
  other vias: 50.8,42.9
S$1261  (via drill 0.2)
  other vias: 49.2,42.9
S$1262  (via drill 0.2)
  other vias: 47.6,42.9
S$1263  (via drill 0.2)
  other vias: 46,42.9
S$1264  (via drill 0.2)
  other vias: 44.4,42.9
S$1265  (via drill 0.2)
  other vias: 42.8,42.9
S$1266  (via drill 0.2)
  other vias: 41.2,42.9
S$1267  (via drill 0.2)
  other vias: 39.6,42.9
S$1268  (via drill 0.2)
  other vias: 38,42.9
S$1269  (via drill 0.2)
  other vias: 36.4,42.9
S$1270  (via drill 0.2)
  other vias: 34.8,38.9
S$1271  (via drill 0.2)
  other vias: 33.2,38.9
S$1272  (via drill 0.2)
  other vias: 31.6,38.9
S$1273  (via drill 0.2)
  other vias: 30,38.9
S$1274  (via drill 0.2)
  other vias: 28.4,38.9
S$1275  (via drill 0.2)
  other vias: 34,42.9
S$1276  (via drill 0.2)
  other vias: 32.4,42.9
S$1277  (via drill 0.2)
  other vias: 30.8,42.9
S$1278  (via drill 0.2)
  other vias: 29.2,42.9
S$1279  (via drill 0.2)
  other vias: 27.6,42.9
S$1280  (via drill 0.2)
  other vias: 26.8,38.9
S$1281  (via drill 0.2)
  other vias: 52.4,42.9
S$1282  (via drill 0.2)
  other vias: 54,42.9
S$1283  (via drill 0.2)
  other vias: 55.6,42.9
S$1284  (via drill 0.2)
  other vias: 57.2,42.9
S$1285  (via drill 0.2)
  other vias: 58.8,42.9
S$1286  (via drill 0.2)
  other vias: 60.4,42.9
S$1287  (via drill 0.2)
  other vias: 62,42.9
S$1288  (via drill 0.2)
  other vias: 63.6,42.9
S$1289  (via drill 0.2)
  other vias: 65.2,42.9
S$1290  (via drill 0.2)
  other vias: 66.8,42.9
S$1291  (via drill 0.2)
  other vias: 68.4,38.9
S$1292  (via drill 0.2)
  other vias: 53.2,38.9
S$1293  (via drill 0.2)
  other vias: 54.8,38.9
S$1294  (via drill 0.2)
  other vias: 56.4,38.9
S$1295  (via drill 0.2)
  other vias: 58,38.9
S$1296  (via drill 0.2)
  other vias: 59.6,38.9
S$1297  (via drill 0.2)
  other vias: 61.2,38.9
S$1298  (via drill 0.2)
  other vias: 62.8,38.9
S$1299  (via drill 0.2)
  other vias: 64.4,38.9
S$1300  (via drill 0.2)
  other vias: 66,38.9
S$1301  (via drill 0.2)
  other vias: 67.6,38.9
S$1302  (via drill 0.2)
  other vias: 69.2,42.9
S$1303  (via drill 0.2)
  other vias: 70.8,42.9
S$1304  (via drill 0.2)
  other vias: 72.4,42.9
S$1305  (via drill 0.2)
  other vias: 70,46.9
S$1306  (via drill 0.2)
  other vias: 71.6,46.9
S$1307  (via drill 0.2)
  other vias: 73.2,46.9
S$1308  (via drill 0.2)
  other vias: 74,42.9
S$1309  (via drill 0.2)
  other vias: 74.8,46.9
S$1310  (via drill 0.2)
  other vias: 75.6,42.9
S$1311  (via drill 0.2)
  other vias: 76.4,46.9
S$1312  (via drill 0.2)
  other vias: 77.2,42.9
S$1313  (via drill 0.2)
  other vias: 102.8,42.9
S$1314  (via drill 0.2)
  other vias: 101.2,42.9
S$1315  (via drill 0.2)
  other vias: 99.6,42.9
S$1316  (via drill 0.2)
  other vias: 98,42.9
S$1317  (via drill 0.2)
  other vias: 96.4,42.9
S$1318  (via drill 0.2)
  other vias: 94.8,42.9
S$1319  (via drill 0.2)
  other vias: 93.2,42.9
S$1320  (via drill 0.2)
  other vias: 91.6,42.9
S$1321  (via drill 0.2)
  other vias: 90,42.9
S$1322  (via drill 0.2)
  other vias: 88.4,42.9
S$1323  (via drill 0.2)
  other vias: 86.8,38.9
S$1324  (via drill 0.2)
  other vias: 102,38.9
S$1325  (via drill 0.2)
  other vias: 100.4,38.9
S$1326  (via drill 0.2)
  other vias: 98.8,38.9
S$1327  (via drill 0.2)
  other vias: 97.2,38.9
S$1328  (via drill 0.2)
  other vias: 95.6,38.9
S$1329  (via drill 0.2)
  other vias: 94,38.9
S$1330  (via drill 0.2)
  other vias: 92.4,38.9
S$1331  (via drill 0.2)
  other vias: 90.8,38.9
S$1332  (via drill 0.2)
  other vias: 89.2,38.9
S$1333  (via drill 0.2)
  other vias: 87.6,38.9
S$1334  (via drill 0.2)
  other vias: 86,42.9
S$1335  (via drill 0.2)
  other vias: 84.4,42.9
S$1336  (via drill 0.2)
  other vias: 82.8,42.9
S$1337  (via drill 0.2)
  other vias: 85.2,46.9
S$1338  (via drill 0.2)
  other vias: 83.6,46.9
S$1339  (via drill 0.2)
  other vias: 82,46.9
S$1340  (via drill 0.2)
  other vias: 81.2,42.9
S$1341  (via drill 0.2)
  other vias: 80.4,46.9
S$1342  (via drill 0.2)
  other vias: 79.6,42.9
S$1343  (via drill 0.2)
  other vias: 78.8,46.9
S$1344  (via drill 0.2)
  other vias: 78,42.9
S$1345
  Bottom 0.152: -0.8,47.9 0.2,46.9
S$1346
  Bottom 0.152: 0.2,46.9 1.2,46.9
S$1347
  Bottom 0.152: 1.2,47.9 1.8,47.9
S$1348
  Bottom 0.152: 1.8,47.9 2.8,46.9
S$1349
  Bottom 0.152: 3.2,47.9 3.4,47.9
S$1350
  Bottom 0.152: 3.4,47.9 4.4,46.9
S$1351
  Bottom 0.152: 5.2,47.9 6,47.1
S$1352
  Bottom 0.152: 6,47.1 6,46.9
S$1353
  Bottom 0.152: 7.2,47.9 7.6,47.5
S$1354
  Bottom 0.152: 7.6,47.5 7.6,46.9
S$1355
  Bottom 0.152: 9.2,47.9 9.2,46.9
S$1356
  Bottom 0.152: 11.2,47.9 10.8,47.5
S$1357
  Bottom 0.152: 10.8,47.5 10.8,46.9
S$1358
  Bottom 0.152: 13.2,47.9 12.4,47.1
S$1359
  Bottom 0.152: 12.4,47.1 12.4,46.9
S$1360
  Bottom 0.152: 15.2,47.9 15,47.9
S$1361
  Bottom 0.152: 15,47.9 14,46.9
S$1362
  Bottom 0.152: 17.2,47.9 16.6,47.9
S$1363
  Bottom 0.152: 16.6,47.9 15.6,46.9
S$1364
  Bottom 0.152: 19.2,47.9 18.2,46.9
S$1365
  Bottom 0.152: 18.2,46.9 17.2,46.9
S$1366
  Bottom 0.152: 0.2,43.9 1.2,42.9
S$1367
  Bottom 0.152: 1.2,42.9 2,42.9
S$1368
  Bottom 0.152: 2.2,43.9 3.2,42.9
S$1369
  Bottom 0.152: 3.2,42.9 3.6,42.9
S$1370
  Bottom 0.152: 4.2,43.9 5.2,42.9
S$1371
  Bottom 0.152: 6.2,43.9 6.8,43.3
S$1372
  Bottom 0.152: 6.8,43.3 6.8,42.9
S$1373
  Bottom 0.152: 8.2,43.9 8.4,43.7
S$1374
  Bottom 0.152: 8.4,43.7 8.4,42.9
S$1375
  Bottom 0.152: 10.2,43.9 10,43.7
S$1376
  Bottom 0.152: 10,43.7 10,42.9
S$1377
  Bottom 0.152: 12.2,43.9 11.6,43.3
S$1378
  Bottom 0.152: 11.6,43.3 11.6,42.9
S$1379
  Bottom 0.152: 14.2,43.9 13.2,42.9
S$1380
  Bottom 0.152: 16.2,43.9 15.2,42.9
S$1381
  Bottom 0.152: 15.2,42.9 14.8,42.9
S$1382
  Bottom 0.152: 18.2,43.9 17.2,42.9
S$1383
  Bottom 0.152: 17.2,42.9 16.4,42.9
S$1384
  Bottom 0.152: 15.4,37.9 16.4,38.9
S$1385
  Bottom 0.152: 16.4,38.9 18,38.9
S$1386
  Bottom 0.152: 17.4,37.9 18.2,37.9
S$1387
  Bottom 0.152: 18.2,37.9 19.2,38.9
S$1388
  Bottom 0.152: 19.2,38.9 19.6,38.9
S$1389
  Bottom 0.152: 19.4,37.9 20.2,37.9
S$1390
  Bottom 0.152: 20.2,37.9 21.2,38.9
S$1391
  Bottom 0.152: 21.4,37.9 21.8,37.9
S$1392
  Bottom 0.152: 21.8,37.9 22.8,38.9
S$1393
  Bottom 0.152: 23.4,37.9 24.4,38.9
S$1394
  Bottom 0.152: 25.4,37.9 26,38.5
S$1395
  Bottom 0.152: 26,38.5 26,38.9
S$1396
  Bottom 0.152: 16.4,41.9 17,41.9
S$1397
  Bottom 0.152: 17,41.9 18,42.9
S$1398
  Bottom 0.152: 18,42.9 18.8,42.9
S$1399
  Bottom 0.152: 18.4,41.9 19,41.9
S$1400
  Bottom 0.152: 19,41.9 20,42.9
S$1401
  Bottom 0.152: 20,42.9 20.4,42.9
S$1402
  Bottom 0.152: 20.4,41.9 21,41.9
S$1403
  Bottom 0.152: 21,41.9 22,42.9
S$1404
  Bottom 0.152: 22.4,41.9 22.6,41.9
S$1405
  Bottom 0.152: 22.6,41.9 23.6,42.9
S$1406
  Bottom 0.152: 24.4,41.9 25.2,42.7
S$1407
  Bottom 0.152: 25.2,42.7 25.2,42.9
S$1408
  Bottom 0.152: 53.6,47.9 52.6,46.9
S$1409
  Bottom 0.152: 52.6,46.9 51.6,46.9
S$1410
  Bottom 0.152: 51.6,47.9 51,47.9
S$1411
  Bottom 0.152: 51,47.9 50,46.9
S$1412
  Bottom 0.152: 49.6,47.9 49.4,47.9
S$1413
  Bottom 0.152: 49.4,47.9 48.4,46.9
S$1414
  Bottom 0.152: 47.6,47.9 46.8,47.1
S$1415
  Bottom 0.152: 46.8,47.1 46.8,46.9
S$1416
  Bottom 0.152: 45.6,47.9 45.2,47.5
S$1417
  Bottom 0.152: 45.2,47.5 45.2,46.9
S$1418
  Bottom 0.152: 43.6,47.9 43.6,46.9
S$1419
  Bottom 0.152: 41.6,47.9 42,47.5
S$1420
  Bottom 0.152: 42,47.5 42,46.9
S$1421
  Bottom 0.152: 39.6,47.9 40.4,47.1
S$1422
  Bottom 0.152: 40.4,47.1 40.4,46.9
S$1423
  Bottom 0.152: 37.6,47.9 37.8,47.9
S$1424
  Bottom 0.152: 37.8,47.9 38.8,46.9
S$1425
  Bottom 0.152: 35.6,47.9 36.2,47.9
S$1426
  Bottom 0.152: 36.2,47.9 37.2,46.9
S$1427
  Bottom 0.152: 33.6,47.9 34.6,46.9
S$1428
  Bottom 0.152: 34.6,46.9 35.6,46.9
S$1429
  Bottom 0.152: 52.6,43.9 51.6,42.9
S$1430
  Bottom 0.152: 51.6,42.9 50.8,42.9
S$1431
  Bottom 0.152: 50.6,43.9 49.6,42.9
S$1432
  Bottom 0.152: 49.6,42.9 49.2,42.9
S$1433
  Bottom 0.152: 48.6,43.9 47.6,42.9
S$1434
  Bottom 0.152: 46.6,43.9 46,43.3
S$1435
  Bottom 0.152: 46,43.3 46,42.9
S$1436
  Bottom 0.152: 44.6,43.9 44.4,43.7
S$1437
  Bottom 0.152: 44.4,43.7 44.4,42.9
S$1438
  Bottom 0.152: 42.6,43.9 42.8,43.7
S$1439
  Bottom 0.152: 42.8,43.7 42.8,42.9
S$1440
  Bottom 0.152: 40.6,43.9 41.2,43.3
S$1441
  Bottom 0.152: 41.2,43.3 41.2,42.9
S$1442
  Bottom 0.152: 38.6,43.9 39.6,42.9
S$1443
  Bottom 0.152: 36.6,43.9 37.6,42.9
S$1444
  Bottom 0.152: 37.6,42.9 38,42.9
S$1445
  Bottom 0.152: 34.6,43.9 35.6,42.9
S$1446
  Bottom 0.152: 35.6,42.9 36.4,42.9
S$1447
  Bottom 0.152: 37.4,37.9 36.4,38.9
S$1448
  Bottom 0.152: 36.4,38.9 34.8,38.9
S$1449
  Bottom 0.152: 35.4,37.9 34.6,37.9
S$1450
  Bottom 0.152: 34.6,37.9 33.6,38.9
S$1451
  Bottom 0.152: 33.6,38.9 33.2,38.9
S$1452
  Bottom 0.152: 33.4,37.9 32.6,37.9
S$1453
  Bottom 0.152: 32.6,37.9 31.6,38.9
S$1454
  Bottom 0.152: 31.4,37.9 31,37.9
S$1455
  Bottom 0.152: 31,37.9 30,38.9
S$1456
  Bottom 0.152: 29.4,37.9 28.4,38.9
S$1457
  Bottom 0.152: 27.4,37.9 26.8,38.5
S$1458
  Bottom 0.152: 26.8,38.5 26.8,38.9
S$1459
  Bottom 0.152: 36.4,41.9 35.8,41.9
S$1460
  Bottom 0.152: 35.8,41.9 34.8,42.9
S$1461
  Bottom 0.152: 34.8,42.9 34,42.9
S$1462
  Bottom 0.152: 34.4,41.9 33.8,41.9
S$1463
  Bottom 0.152: 33.8,41.9 32.8,42.9
S$1464
  Bottom 0.152: 32.8,42.9 32.4,42.9
S$1465
  Bottom 0.152: 32.4,41.9 31.8,41.9
S$1466
  Bottom 0.152: 31.8,41.9 30.8,42.9
S$1467
  Bottom 0.152: 30.4,41.9 30.2,41.9
S$1468
  Bottom 0.152: 30.2,41.9 29.2,42.9
S$1469
  Bottom 0.152: 28.4,41.9 27.6,42.7
S$1470
  Bottom 0.152: 27.6,42.7 27.6,42.9
S$1471
  Bottom 0.152: 52.4,41.9 53,41.9
S$1472
  Bottom 0.152: 53,41.9 54,42.9
S$1473
  Bottom 0.152: 54.4,41.9 54.6,41.9
S$1474
  Bottom 0.152: 54.6,41.9 55.6,42.9
S$1475
  Bottom 0.152: 56.4,41.9 57.2,42.7
S$1476
  Bottom 0.152: 57.2,42.7 57.2,42.9
S$1477
  Bottom 0.152: 58.4,41.9 58.8,42.3
S$1478
  Bottom 0.152: 58.8,42.3 58.8,42.9
S$1479
  Bottom 0.152: 60.4,41.9 60.4,42.9
S$1480
  Bottom 0.152: 50.4,41.9 51.4,41.9
S$1481
  Bottom 0.152: 51.4,41.9 52.4,42.9
S$1482
  Bottom 0.152: 51.4,37.9 52.4,38.9
S$1483
  Bottom 0.152: 52.4,38.9 53.2,38.9
S$1484
  Bottom 0.152: 53.4,37.9 53.8,37.9
S$1485
  Bottom 0.152: 53.8,37.9 54.8,38.9
S$1486
  Bottom 0.152: 55.4,37.9 56.4,38.9
S$1487
  Bottom 0.152: 57.4,37.9 58,38.5
S$1488
  Bottom 0.152: 58,38.5 58,38.9
S$1489
  Bottom 0.152: 59.4,37.9 59.6,38.1
S$1490
  Bottom 0.152: 59.6,38.1 59.6,38.9
S$1491
  Bottom 0.152: 61.4,37.9 61.2,38.1
S$1492
  Bottom 0.152: 61.2,38.1 61.2,38.9
S$1493
  Bottom 0.152: 63.4,37.9 62.8,38.5
S$1494
  Bottom 0.152: 62.8,38.5 62.8,38.9
S$1495
  Bottom 0.152: 65.4,37.9 64.4,38.9
S$1496
  Bottom 0.152: 67.4,37.9 67,37.9
S$1497
  Bottom 0.152: 67,37.9 66,38.9
S$1498
  Bottom 0.152: 69.4,37.9 68.6,37.9
S$1499
  Bottom 0.152: 68.6,37.9 67.6,38.9
S$1500
  Bottom 0.152: 62.4,41.9 62,42.3
S$1501
  Bottom 0.152: 62,42.3 62,42.9
S$1502
  Bottom 0.152: 64.4,41.9 63.6,42.7
S$1503
  Bottom 0.152: 63.6,42.7 63.6,42.9
S$1504
  Bottom 0.152: 66.4,41.9 66.2,41.9
S$1505
  Bottom 0.152: 66.2,41.9 65.2,42.9
S$1506
  Bottom 0.152: 68.4,41.9 67.8,41.9
S$1507
  Bottom 0.152: 67.8,41.9 66.8,42.9
S$1508
  Bottom 0.152: 70.4,39.9 69.4,38.9
S$1509
  Bottom 0.152: 69.4,38.9 68.4,38.9
S$1510
  Bottom 0.152: 68.6,43.9 69.2,43.9
S$1511
  Bottom 0.152: 69.2,43.9 70.2,42.9
S$1512
  Bottom 0.152: 70.2,42.9 70.8,42.9
S$1513
  Bottom 0.152: 70.6,43.9 71.6,42.9
S$1514
  Bottom 0.152: 71.6,42.9 72.4,42.9
S$1515
  Bottom 0.152: 72.6,43.9 73.6,42.9
S$1516
  Bottom 0.152: 73.6,42.9 74,42.9
S$1517
  Bottom 0.152: 74.6,43.9 75.6,42.9
S$1518
  Bottom 0.152: 76.6,43.9 77.2,43.3
S$1519
  Bottom 0.152: 77.2,43.3 77.2,42.9
S$1520
  Bottom 0.152: 67.6,47.9 68.6,46.9
S$1521
  Bottom 0.152: 68.6,46.9 70,46.9
S$1522
  Bottom 0.152: 69.6,47.9 70,47.9
S$1523
  Bottom 0.152: 70,47.9 71,46.9
S$1524
  Bottom 0.152: 71,46.9 71.6,46.9
S$1525
  Bottom 0.152: 71.6,47.9 72.2,47.9
S$1526
  Bottom 0.152: 72.2,47.9 73.2,46.9
S$1527
  Bottom 0.152: 73.6,47.9 73.8,47.9
S$1528
  Bottom 0.152: 73.8,47.9 74.8,46.9
S$1529
  Bottom 0.152: 75.6,47.9 76.4,47.1
S$1530
  Bottom 0.152: 76.4,47.1 76.4,46.9
S$1531
  Bottom 0.152: 69.2,42.9 68,42.9
S$1532
  Bottom 0.152: 68,42.9 67,43.9
S$1533
  Bottom 0.152: 67,43.9 66.6,43.9
S$1534
  Bottom 0.152: 102.8,41.9 102.2,41.9
S$1535
  Bottom 0.152: 102.2,41.9 101.2,42.9
S$1536
  Bottom 0.152: 100.8,41.9 100.6,41.9
S$1537
  Bottom 0.152: 100.6,41.9 99.6,42.9
S$1538
  Bottom 0.152: 98.8,41.9 98,42.7
S$1539
  Bottom 0.152: 98,42.7 98,42.9
S$1540
  Bottom 0.152: 96.8,41.9 96.4,42.3
S$1541
  Bottom 0.152: 96.4,42.3 96.4,42.9
S$1542
  Bottom 0.152: 94.8,41.9 94.8,42.9
S$1543
  Bottom 0.152: 104.8,41.9 103.8,41.9
S$1544
  Bottom 0.152: 103.8,41.9 102.8,42.9
S$1545
  Bottom 0.152: 103.8,37.9 102.8,38.9
S$1546
  Bottom 0.152: 102.8,38.9 102,38.9
S$1547
  Bottom 0.152: 101.8,37.9 101.4,37.9
S$1548
  Bottom 0.152: 101.4,37.9 100.4,38.9
S$1549
  Bottom 0.152: 99.8,37.9 98.8,38.9
S$1550
  Bottom 0.152: 97.8,37.9 97.2,38.5
S$1551
  Bottom 0.152: 97.2,38.5 97.2,38.9
S$1552
  Bottom 0.152: 95.8,37.9 95.6,38.1
S$1553
  Bottom 0.152: 95.6,38.1 95.6,38.9
S$1554
  Bottom 0.152: 93.8,37.9 94,38.1
S$1555
  Bottom 0.152: 94,38.1 94,38.9
S$1556
  Bottom 0.152: 91.8,37.9 92.4,38.5
S$1557
  Bottom 0.152: 92.4,38.5 92.4,38.9
S$1558
  Bottom 0.152: 89.8,37.9 90.8,38.9
S$1559
  Bottom 0.152: 87.8,37.9 88.2,37.9
S$1560
  Bottom 0.152: 88.2,37.9 89.2,38.9
S$1561
  Bottom 0.152: 85.8,37.9 86.6,37.9
S$1562
  Bottom 0.152: 86.6,37.9 87.6,38.9
S$1563
  Bottom 0.152: 92.8,41.9 93.2,42.3
S$1564
  Bottom 0.152: 93.2,42.3 93.2,42.9
S$1565
  Bottom 0.152: 90.8,41.9 91.6,42.7
S$1566
  Bottom 0.152: 91.6,42.7 91.6,42.9
S$1567
  Bottom 0.152: 88.8,41.9 89,41.9
S$1568
  Bottom 0.152: 89,41.9 90,42.9
S$1569
  Bottom 0.152: 86.8,41.9 87.4,41.9
S$1570
  Bottom 0.152: 87.4,41.9 88.4,42.9
S$1571
  Bottom 0.152: 84.8,39.9 85.8,38.9
S$1572
  Bottom 0.152: 85.8,38.9 86.8,38.9
S$1573
  Bottom 0.152: 86.6,43.9 86,43.9
S$1574
  Bottom 0.152: 86,43.9 85,42.9
S$1575
  Bottom 0.152: 85,42.9 84.4,42.9
S$1576
  Bottom 0.152: 84.6,43.9 83.6,42.9
S$1577
  Bottom 0.152: 83.6,42.9 82.8,42.9
S$1578
  Bottom 0.152: 82.6,43.9 81.6,42.9
S$1579
  Bottom 0.152: 81.6,42.9 81.2,42.9
S$1580
  Bottom 0.152: 80.6,43.9 79.6,42.9
S$1581
  Bottom 0.152: 78.6,43.9 78,43.3
S$1582
  Bottom 0.152: 78,43.3 78,42.9
S$1583
  Bottom 0.152: 87.6,47.9 86.6,46.9
S$1584
  Bottom 0.152: 86.6,46.9 85.2,46.9
S$1585
  Bottom 0.152: 85.6,47.9 85.2,47.9
S$1586
  Bottom 0.152: 85.2,47.9 84.2,46.9
S$1587
  Bottom 0.152: 84.2,46.9 83.6,46.9
S$1588
  Bottom 0.152: 83.6,47.9 83,47.9
S$1589
  Bottom 0.152: 83,47.9 82,46.9
S$1590
  Bottom 0.152: 81.6,47.9 81.4,47.9
S$1591
  Bottom 0.152: 81.4,47.9 80.4,46.9
S$1592
  Bottom 0.152: 79.6,47.9 78.8,47.1
S$1593
  Bottom 0.152: 78.8,47.1 78.8,46.9
S$1594
  Bottom 0.152: 86,42.9 87.2,42.9
S$1595
  Bottom 0.152: 87.2,42.9 88.2,43.9
S$1596
  Bottom 0.152: 88.2,43.9 88.6,43.9
S$1597  (2 unrouted)
  Top 0.508: 117,47.4 117,42.9 | 117,42.9 117,38.4 | 117,42.9 146,42.9 146,44.9
  Top 1.8: 118,44.4 116,44.4 | 118,47.4 117,47.4 116,47.4 | 118,41.4 116,41.4 | 118,38.4 117,38.4 116,38.4
S$1598
  Top 1.778: -52.08,39.73 -52.08,41.25
S$1599
  Top 1.778: -52.08,44.55 -52.08,46.07
S$1600
  Top 1.778: -47,39.73 -47,41.25
S$1601
  Top 1.778: -47,44.55 -47,46.07
S$1602
  Top 1.778: -41.92,39.73 -41.92,41.25
S$1603
  Top 1.778: -41.92,44.55 -41.92,46.07
S$1604
  Top 1.778: 145.92,39.73 145.92,41.25
S$1605
  Top 1.778: 145.92,44.55 145.92,46.07
S$1606
  Top 1.778: 151,39.73 151,41.25
S$1607
  Top 1.778: 151,44.55 151,46.07
S$1608
  Top 1.778: 156.08,39.73 156.08,41.25
S$1609
  Top 1.778: 156.08,44.55 156.08,46.07
S$1610  (via drill 0.2)
  other vias: 26.4,49.3
S$1611  (via drill 0.2)
  other vias: 43.4,36.5
S$1612  (via drill 0.2)
  other vias: 60.6,49.3
S$1613  (via drill 0.2)
  other vias: 77.6,36.5
S$1614  (via drill 0.2)
  other vias: 93.6,49.3
S$1615  (via drill 0.2)
  other vias: 104.8,49.3
S$1616  (via drill 0.2)
  other vias: 10.4,36.5
S$1617  (via drill 0.2)
  other vias: -0.8,36.5
S$1618
  Bottom 0.8: 61.4,55.8 61.4,54
S$1619
  Bottom 0.8: 63.4,55.8 63.4,54
S$1620
  Bottom 0.8: 60.4,58 60.4,59.8
S$1621
  Bottom 0.8: 62.4,58 62.4,59.8
S$1622
  Bottom 0.8: 57.4,55.8 57.4,54
S$1623
  Bottom 0.8: 59.4,55.8 59.4,54
S$1624
  Bottom 0.8: 58.4,58 58.4,59.8
S$1625
  Bottom 0.8: 56.4,58 56.4,59.8
S$1626
  Bottom 0.8: 55.4,55.8 55.4,54
S$1627
  Bottom 0.8: 53.4,55.8 53.4,54
S$1628
  Bottom 0.8: 54.4,58 54.4,59.8
S$1629
  Bottom 0.8: 52.4,58 52.4,59.8
S$1630
  Bottom 0.8: 51.4,55.8 51.4,54
S$1631
  Bottom 0.8: 49.4,55.8 49.4,54
S$1632
  Bottom 0.8: 50.4,58 50.4,59.8
S$1633
  Bottom 0.8: 69.4,55.8 69.4,54
S$1634
  Bottom 0.8: 71.4,55.8 71.4,54
S$1635
  Bottom 0.8: 68.4,58 68.4,59.8
S$1636
  Bottom 0.8: 70.4,58 70.4,59.8
S$1637
  Bottom 0.8: 65.4,55.8 65.4,54
S$1638
  Bottom 0.8: 67.4,55.8 67.4,54
S$1639
  Bottom 0.8: 64.4,58 64.4,59.8
S$1640
  Bottom 0.8: 66.4,58 66.4,59.8
S$1641
  Bottom 0.8: 44.6,63.8 44.6,62
S$1642
  Bottom 0.8: 46.6,63.8 46.6,62
S$1643
  Bottom 0.8: 43.6,66 43.6,67.8
S$1644
  Bottom 0.8: 45.6,66 45.6,67.8
S$1645
  Bottom 0.8: 40.6,63.8 40.6,62
S$1646
  Bottom 0.8: 42.6,63.8 42.6,62
S$1647
  Bottom 0.8: 41.6,66 41.6,67.8
S$1648
  Bottom 0.8: 39.6,66 39.6,67.8
S$1649
  Bottom 0.8: 38.6,63.8 38.6,62
S$1650
  Bottom 0.8: 36.6,63.8 36.6,62
S$1651
  Bottom 0.8: 37.6,66 37.6,67.8
S$1652
  Bottom 0.8: 35.6,66 35.6,67.8
S$1653
  Bottom 0.8: 34.6,63.8 34.6,62
S$1654
  Bottom 0.8: 32.6,63.8 32.6,62
S$1655
  Bottom 0.8: 33.6,66 33.6,67.8
S$1656
  Bottom 0.8: 52.6,63.8 52.6,62
S$1657
  Bottom 0.8: 54.6,63.8 54.6,62
S$1658
  Bottom 0.8: 51.6,66 51.6,67.8
S$1659
  Bottom 0.8: 53.6,66 53.6,67.8
S$1660
  Bottom 0.8: 48.6,63.8 48.6,62
S$1661
  Bottom 0.8: 50.6,63.8 50.6,62
S$1662
  Bottom 0.8: 47.6,66 47.6,67.8
S$1663
  Bottom 0.8: 49.6,66 49.6,67.8
S$1664
  Bottom 0.8: 27.4,55.8 27.4,54
S$1665
  Bottom 0.8: 29.4,55.8 29.4,54
S$1666
  Bottom 0.8: 26.4,58 26.4,59.8
S$1667
  Bottom 0.8: 28.4,58 28.4,59.8
S$1668
  Bottom 0.8: 23.4,55.8 23.4,54
S$1669
  Bottom 0.8: 25.4,55.8 25.4,54
S$1670
  Bottom 0.8: 24.4,58 24.4,59.8
S$1671
  Bottom 0.8: 22.4,58 22.4,59.8
S$1672
  Bottom 0.8: 21.4,55.8 21.4,54
S$1673
  Bottom 0.8: 19.4,55.8 19.4,54
S$1674
  Bottom 0.8: 20.4,58 20.4,59.8
S$1675
  Bottom 0.8: 18.4,58 18.4,59.8
S$1676
  Bottom 0.8: 17.4,55.8 17.4,54
S$1677
  Bottom 0.8: 15.4,55.8 15.4,54
S$1678
  Bottom 0.8: 16.4,58 16.4,59.8
S$1679
  Bottom 0.8: 35.4,55.8 35.4,54
S$1680
  Bottom 0.8: 37.4,55.8 37.4,54
S$1681
  Bottom 0.8: 34.4,58 34.4,59.8
S$1682
  Bottom 0.8: 36.4,58 36.4,59.8
S$1683
  Bottom 0.8: 31.4,55.8 31.4,54
S$1684
  Bottom 0.8: 33.4,55.8 33.4,54
S$1685
  Bottom 0.8: 30.4,58 30.4,59.8
S$1686
  Bottom 0.8: 32.4,58 32.4,59.8
S$1687
  Bottom 0.8: 78.6,63.8 78.6,62
S$1688
  Bottom 0.8: 80.6,63.8 80.6,62
S$1689
  Bottom 0.8: 77.6,66 77.6,67.8
S$1690
  Bottom 0.8: 79.6,66 79.6,67.8
S$1691
  Bottom 0.8: 74.6,63.8 74.6,62
S$1692
  Bottom 0.8: 76.6,63.8 76.6,62
S$1693
  Bottom 0.8: 75.6,66 75.6,67.8
S$1694
  Bottom 0.8: 73.6,66 73.6,67.8
S$1695
  Bottom 0.8: 72.6,63.8 72.6,62
S$1696
  Bottom 0.8: 70.6,63.8 70.6,62
S$1697
  Bottom 0.8: 71.6,66 71.6,67.8
S$1698
  Bottom 0.8: 69.6,66 69.6,67.8
S$1699
  Bottom 0.8: 68.6,63.8 68.6,62
S$1700
  Bottom 0.8: 66.6,63.8 66.6,62
S$1701
  Bottom 0.8: 67.6,66 67.6,67.8
S$1702
  Bottom 0.8: 86.6,63.8 86.6,62
S$1703
  Bottom 0.8: 88.6,63.8 88.6,62
S$1704
  Bottom 0.8: 85.6,66 85.6,67.8
S$1705
  Bottom 0.8: 87.6,66 87.6,67.8
S$1706
  Bottom 0.8: 82.6,63.8 82.6,62
S$1707
  Bottom 0.8: 84.6,63.8 84.6,62
S$1708
  Bottom 0.8: 81.6,66 81.6,67.8
S$1709
  Bottom 0.8: 83.6,66 83.6,67.8
S$1710
  Bottom 0.8: 10.2,63.8 10.2,62
S$1711
  Bottom 0.8: 12.2,63.8 12.2,62
S$1712
  Bottom 0.8: 9.2,66 9.2,67.8
S$1713
  Bottom 0.8: 11.2,66 11.2,67.8
S$1714
  Bottom 0.8: 6.2,63.8 6.2,62
S$1715
  Bottom 0.8: 8.2,63.8 8.2,62
S$1716
  Bottom 0.8: 7.2,66 7.2,67.8
S$1717
  Bottom 0.8: 5.2,66 5.2,67.8
S$1718
  Bottom 0.8: 4.2,63.8 4.2,62
S$1719
  Bottom 0.8: 2.2,63.8 2.2,62
S$1720
  Bottom 0.8: 3.2,66 3.2,67.8
S$1721
  Bottom 0.8: 1.2,66 1.2,67.8
S$1722
  Bottom 0.8: 0.2,63.8 0.2,62
S$1723
  Bottom 0.8: -1.8,63.8 -1.8,62
S$1724
  Bottom 0.8: -0.8,66 -0.8,67.8
S$1725
  Bottom 0.8: 18.2,63.8 18.2,62
S$1726
  Bottom 0.8: 20.2,63.8 20.2,62
S$1727
  Bottom 0.8: 17.2,66 17.2,67.8
S$1728
  Bottom 0.8: 19.2,66 19.2,67.8
S$1729
  Bottom 0.8: 14.2,63.8 14.2,62
S$1730
  Bottom 0.8: 16.2,63.8 16.2,62
S$1731
  Bottom 0.8: 13.2,66 13.2,67.8
S$1732
  Bottom 0.8: 15.2,66 15.2,67.8
S$1733
  Bottom 0.8: 95.8,55.8 95.8,54
S$1734
  Bottom 0.8: 97.8,55.8 97.8,54
S$1735
  Bottom 0.8: 94.8,58 94.8,59.8
S$1736
  Bottom 0.8: 96.8,58 96.8,59.8
S$1737
  Bottom 0.8: 91.8,55.8 91.8,54
S$1738
  Bottom 0.8: 93.8,55.8 93.8,54
S$1739
  Bottom 0.8: 92.8,58 92.8,59.8
S$1740
  Bottom 0.8: 90.8,58 90.8,59.8
S$1741
  Bottom 0.8: 89.8,55.8 89.8,54
S$1742
  Bottom 0.8: 87.8,55.8 87.8,54
S$1743
  Bottom 0.8: 88.8,58 88.8,59.8
S$1744
  Bottom 0.8: 86.8,58 86.8,59.8
S$1745
  Bottom 0.8: 85.8,55.8 85.8,54
S$1746
  Bottom 0.8: 83.8,55.8 83.8,54
S$1747
  Bottom 0.8: 84.8,58 84.8,59.8
S$1748
  Bottom 0.8: 103.8,55.8 103.8,54
S$1749
  Bottom 0.8: 105.8,55.8 105.8,54
S$1750
  Bottom 0.8: 102.8,58 102.8,59.8
S$1751
  Bottom 0.8: 104.8,58 104.8,59.8
S$1752
  Bottom 0.8: 99.8,55.8 99.8,54
S$1753
  Bottom 0.8: 101.8,55.8 101.8,54
S$1754
  Bottom 0.8: 98.8,58 98.8,59.8
S$1755
  Bottom 0.8: 100.8,58 100.8,59.8
S$1756  (via drill 0.2)
  other vias: 1.2,64.9
S$1757  (via drill 0.2)
  other vias: 2.8,64.9
S$1758  (via drill 0.2)
  other vias: 4.4,64.9
S$1759  (via drill 0.2)
  other vias: 6,64.9
S$1760  (via drill 0.2)
  other vias: 7.6,64.9
S$1761  (via drill 0.2)
  other vias: 9.2,64.9
S$1762  (via drill 0.2)
  other vias: 10.8,64.9
S$1763  (via drill 0.2)
  other vias: 12.4,64.9
S$1764  (via drill 0.2)
  other vias: 14,64.9
S$1765  (via drill 0.2)
  other vias: 15.6,64.9
S$1766  (via drill 0.2)
  other vias: 17.2,64.9
S$1767  (via drill 0.2)
  other vias: 2,60.9
S$1768  (via drill 0.2)
  other vias: 3.6,60.9
S$1769  (via drill 0.2)
  other vias: 5.2,60.9
S$1770  (via drill 0.2)
  other vias: 6.8,60.9
S$1771  (via drill 0.2)
  other vias: 8.4,60.9
S$1772  (via drill 0.2)
  other vias: 10,60.9
S$1773  (via drill 0.2)
  other vias: 11.6,60.9
S$1774  (via drill 0.2)
  other vias: 13.2,60.9
S$1775  (via drill 0.2)
  other vias: 14.8,60.9
S$1776  (via drill 0.2)
  other vias: 16.4,60.9
S$1777  (via drill 0.2)
  other vias: 18,56.9
S$1778  (via drill 0.2)
  other vias: 19.6,56.9
S$1779  (via drill 0.2)
  other vias: 21.2,56.9
S$1780  (via drill 0.2)
  other vias: 22.8,56.9
S$1781  (via drill 0.2)
  other vias: 24.4,56.9
S$1782  (via drill 0.2)
  other vias: 18.8,60.9
S$1783  (via drill 0.2)
  other vias: 20.4,60.9
S$1784  (via drill 0.2)
  other vias: 22,60.9
S$1785  (via drill 0.2)
  other vias: 23.6,60.9
S$1786  (via drill 0.2)
  other vias: 25.2,60.9
S$1787  (via drill 0.2)
  other vias: 26,56.9
S$1788  (via drill 0.2)
  other vias: 51.6,64.9
S$1789  (via drill 0.2)
  other vias: 50,64.9
S$1790  (via drill 0.2)
  other vias: 48.4,64.9
S$1791  (via drill 0.2)
  other vias: 46.8,64.9
S$1792  (via drill 0.2)
  other vias: 45.2,64.9
S$1793  (via drill 0.2)
  other vias: 43.6,64.9
S$1794  (via drill 0.2)
  other vias: 42,64.9
S$1795  (via drill 0.2)
  other vias: 40.4,64.9
S$1796  (via drill 0.2)
  other vias: 38.8,64.9
S$1797  (via drill 0.2)
  other vias: 37.2,64.9
S$1798  (via drill 0.2)
  other vias: 35.6,64.9
S$1799  (via drill 0.2)
  other vias: 50.8,60.9
S$1800  (via drill 0.2)
  other vias: 49.2,60.9
S$1801  (via drill 0.2)
  other vias: 47.6,60.9
S$1802  (via drill 0.2)
  other vias: 46,60.9
S$1803  (via drill 0.2)
  other vias: 44.4,60.9
S$1804  (via drill 0.2)
  other vias: 42.8,60.9
S$1805  (via drill 0.2)
  other vias: 41.2,60.9
S$1806  (via drill 0.2)
  other vias: 39.6,60.9
S$1807  (via drill 0.2)
  other vias: 38,60.9
S$1808  (via drill 0.2)
  other vias: 36.4,60.9
S$1809  (via drill 0.2)
  other vias: 34.8,56.9
S$1810  (via drill 0.2)
  other vias: 33.2,56.9
S$1811  (via drill 0.2)
  other vias: 31.6,56.9
S$1812  (via drill 0.2)
  other vias: 30,56.9
S$1813  (via drill 0.2)
  other vias: 28.4,56.9
S$1814  (via drill 0.2)
  other vias: 34,60.9
S$1815  (via drill 0.2)
  other vias: 32.4,60.9
S$1816  (via drill 0.2)
  other vias: 30.8,60.9
S$1817  (via drill 0.2)
  other vias: 29.2,60.9
S$1818  (via drill 0.2)
  other vias: 27.6,60.9
S$1819  (via drill 0.2)
  other vias: 26.8,56.9
S$1820  (via drill 0.2)
  other vias: 52.4,60.9
S$1821  (via drill 0.2)
  other vias: 54,60.9
S$1822  (via drill 0.2)
  other vias: 55.6,60.9
S$1823  (via drill 0.2)
  other vias: 57.2,60.9
S$1824  (via drill 0.2)
  other vias: 58.8,60.9
S$1825  (via drill 0.2)
  other vias: 60.4,60.9
S$1826  (via drill 0.2)
  other vias: 62,60.9
S$1827  (via drill 0.2)
  other vias: 63.6,60.9
S$1828  (via drill 0.2)
  other vias: 65.2,60.9
S$1829  (via drill 0.2)
  other vias: 66.8,60.9
S$1830  (via drill 0.2)
  other vias: 68.4,56.9
S$1831  (via drill 0.2)
  other vias: 53.2,56.9
S$1832  (via drill 0.2)
  other vias: 54.8,56.9
S$1833  (via drill 0.2)
  other vias: 56.4,56.9
S$1834  (via drill 0.2)
  other vias: 58,56.9
S$1835  (via drill 0.2)
  other vias: 59.6,56.9
S$1836  (via drill 0.2)
  other vias: 61.2,56.9
S$1837  (via drill 0.2)
  other vias: 62.8,56.9
S$1838  (via drill 0.2)
  other vias: 64.4,56.9
S$1839  (via drill 0.2)
  other vias: 66,56.9
S$1840  (via drill 0.2)
  other vias: 67.6,56.9
S$1841  (via drill 0.2)
  other vias: 69.2,60.9
S$1842  (via drill 0.2)
  other vias: 70.8,60.9
S$1843  (via drill 0.2)
  other vias: 72.4,60.9
S$1844  (via drill 0.2)
  other vias: 70,64.9
S$1845  (via drill 0.2)
  other vias: 71.6,64.9
S$1846  (via drill 0.2)
  other vias: 73.2,64.9
S$1847  (via drill 0.2)
  other vias: 74,60.9
S$1848  (via drill 0.2)
  other vias: 74.8,64.9
S$1849  (via drill 0.2)
  other vias: 75.6,60.9
S$1850  (via drill 0.2)
  other vias: 76.4,64.9
S$1851  (via drill 0.2)
  other vias: 77.2,60.9
S$1852  (via drill 0.2)
  other vias: 102.8,60.9
S$1853  (via drill 0.2)
  other vias: 101.2,60.9
S$1854  (via drill 0.2)
  other vias: 99.6,60.9
S$1855  (via drill 0.2)
  other vias: 98,60.9
S$1856  (via drill 0.2)
  other vias: 96.4,60.9
S$1857  (via drill 0.2)
  other vias: 94.8,60.9
S$1858  (via drill 0.2)
  other vias: 93.2,60.9
S$1859  (via drill 0.2)
  other vias: 91.6,60.9
S$1860  (via drill 0.2)
  other vias: 90,60.9
S$1861  (via drill 0.2)
  other vias: 88.4,60.9
S$1862  (via drill 0.2)
  other vias: 86.8,56.9
S$1863  (via drill 0.2)
  other vias: 102,56.9
S$1864  (via drill 0.2)
  other vias: 100.4,56.9
S$1865  (via drill 0.2)
  other vias: 98.8,56.9
S$1866  (via drill 0.2)
  other vias: 97.2,56.9
S$1867  (via drill 0.2)
  other vias: 95.6,56.9
S$1868  (via drill 0.2)
  other vias: 94,56.9
S$1869  (via drill 0.2)
  other vias: 92.4,56.9
S$1870  (via drill 0.2)
  other vias: 90.8,56.9
S$1871  (via drill 0.2)
  other vias: 89.2,56.9
S$1872  (via drill 0.2)
  other vias: 87.6,56.9
S$1873  (via drill 0.2)
  other vias: 86,60.9
S$1874  (via drill 0.2)
  other vias: 84.4,60.9
S$1875  (via drill 0.2)
  other vias: 82.8,60.9
S$1876  (via drill 0.2)
  other vias: 85.2,64.9
S$1877  (via drill 0.2)
  other vias: 83.6,64.9
S$1878  (via drill 0.2)
  other vias: 82,64.9
S$1879  (via drill 0.2)
  other vias: 81.2,60.9
S$1880  (via drill 0.2)
  other vias: 80.4,64.9
S$1881  (via drill 0.2)
  other vias: 79.6,60.9
S$1882  (via drill 0.2)
  other vias: 78.8,64.9
S$1883  (via drill 0.2)
  other vias: 78,60.9
S$1884
  Bottom 0.152: -0.8,65.9 0.2,64.9
S$1885
  Bottom 0.152: 0.2,64.9 1.2,64.9
S$1886
  Bottom 0.152: 1.2,65.9 1.8,65.9
S$1887
  Bottom 0.152: 1.8,65.9 2.8,64.9
S$1888
  Bottom 0.152: 3.2,65.9 3.4,65.9
S$1889
  Bottom 0.152: 3.4,65.9 4.4,64.9
S$1890
  Bottom 0.152: 5.2,65.9 6,65.1
S$1891
  Bottom 0.152: 6,65.1 6,64.9
S$1892
  Bottom 0.152: 7.2,65.9 7.6,65.5
S$1893
  Bottom 0.152: 7.6,65.5 7.6,64.9
S$1894
  Bottom 0.152: 9.2,65.9 9.2,64.9
S$1895
  Bottom 0.152: 11.2,65.9 10.8,65.5
S$1896
  Bottom 0.152: 10.8,65.5 10.8,64.9
S$1897
  Bottom 0.152: 13.2,65.9 12.4,65.1
S$1898
  Bottom 0.152: 12.4,65.1 12.4,64.9
S$1899
  Bottom 0.152: 15.2,65.9 15,65.9
S$1900
  Bottom 0.152: 15,65.9 14,64.9
S$1901
  Bottom 0.152: 17.2,65.9 16.6,65.9
S$1902
  Bottom 0.152: 16.6,65.9 15.6,64.9
S$1903
  Bottom 0.152: 19.2,65.9 18.2,64.9
S$1904
  Bottom 0.152: 18.2,64.9 17.2,64.9
S$1905
  Bottom 0.152: 0.2,61.9 1.2,60.9
S$1906
  Bottom 0.152: 1.2,60.9 2,60.9
S$1907
  Bottom 0.152: 2.2,61.9 3.2,60.9
S$1908
  Bottom 0.152: 3.2,60.9 3.6,60.9
S$1909
  Bottom 0.152: 4.2,61.9 5.2,60.9
S$1910
  Bottom 0.152: 6.2,61.9 6.8,61.3
S$1911
  Bottom 0.152: 6.8,61.3 6.8,60.9
S$1912
  Bottom 0.152: 8.2,61.9 8.4,61.7
S$1913
  Bottom 0.152: 8.4,61.7 8.4,60.9
S$1914
  Bottom 0.152: 10.2,61.9 10,61.7
S$1915
  Bottom 0.152: 10,61.7 10,60.9
S$1916
  Bottom 0.152: 12.2,61.9 11.6,61.3
S$1917
  Bottom 0.152: 11.6,61.3 11.6,60.9
S$1918
  Bottom 0.152: 14.2,61.9 13.2,60.9
S$1919
  Bottom 0.152: 16.2,61.9 15.2,60.9
S$1920
  Bottom 0.152: 15.2,60.9 14.8,60.9
S$1921
  Bottom 0.152: 18.2,61.9 17.2,60.9
S$1922
  Bottom 0.152: 17.2,60.9 16.4,60.9
S$1923
  Bottom 0.152: 15.4,55.9 16.4,56.9
S$1924
  Bottom 0.152: 16.4,56.9 18,56.9
S$1925
  Bottom 0.152: 17.4,55.9 18.2,55.9
S$1926
  Bottom 0.152: 18.2,55.9 19.2,56.9
S$1927
  Bottom 0.152: 19.2,56.9 19.6,56.9
S$1928
  Bottom 0.152: 19.4,55.9 20.2,55.9
S$1929
  Bottom 0.152: 20.2,55.9 21.2,56.9
S$1930
  Bottom 0.152: 21.4,55.9 21.8,55.9
S$1931
  Bottom 0.152: 21.8,55.9 22.8,56.9
S$1932
  Bottom 0.152: 23.4,55.9 24.4,56.9
S$1933
  Bottom 0.152: 25.4,55.9 26,56.5
S$1934
  Bottom 0.152: 26,56.5 26,56.9
S$1935
  Bottom 0.152: 16.4,59.9 17,59.9
S$1936
  Bottom 0.152: 17,59.9 18,60.9
S$1937
  Bottom 0.152: 18,60.9 18.8,60.9
S$1938
  Bottom 0.152: 18.4,59.9 19,59.9
S$1939
  Bottom 0.152: 19,59.9 20,60.9
S$1940
  Bottom 0.152: 20,60.9 20.4,60.9
S$1941
  Bottom 0.152: 20.4,59.9 21,59.9
S$1942
  Bottom 0.152: 21,59.9 22,60.9
S$1943
  Bottom 0.152: 22.4,59.9 22.6,59.9
S$1944
  Bottom 0.152: 22.6,59.9 23.6,60.9
S$1945
  Bottom 0.152: 24.4,59.9 25.2,60.7
S$1946
  Bottom 0.152: 25.2,60.7 25.2,60.9
S$1947
  Bottom 0.152: 53.6,65.9 52.6,64.9
S$1948
  Bottom 0.152: 52.6,64.9 51.6,64.9
S$1949
  Bottom 0.152: 51.6,65.9 51,65.9
S$1950
  Bottom 0.152: 51,65.9 50,64.9
S$1951
  Bottom 0.152: 49.6,65.9 49.4,65.9
S$1952
  Bottom 0.152: 49.4,65.9 48.4,64.9
S$1953
  Bottom 0.152: 47.6,65.9 46.8,65.1
S$1954
  Bottom 0.152: 46.8,65.1 46.8,64.9
S$1955
  Bottom 0.152: 45.6,65.9 45.2,65.5
S$1956
  Bottom 0.152: 45.2,65.5 45.2,64.9
S$1957
  Bottom 0.152: 43.6,65.9 43.6,64.9
S$1958
  Bottom 0.152: 41.6,65.9 42,65.5
S$1959
  Bottom 0.152: 42,65.5 42,64.9
S$1960
  Bottom 0.152: 39.6,65.9 40.4,65.1
S$1961
  Bottom 0.152: 40.4,65.1 40.4,64.9
S$1962
  Bottom 0.152: 37.6,65.9 37.8,65.9
S$1963
  Bottom 0.152: 37.8,65.9 38.8,64.9
S$1964
  Bottom 0.152: 35.6,65.9 36.2,65.9
S$1965
  Bottom 0.152: 36.2,65.9 37.2,64.9
S$1966
  Bottom 0.152: 33.6,65.9 34.6,64.9
S$1967
  Bottom 0.152: 34.6,64.9 35.6,64.9
S$1968
  Bottom 0.152: 52.6,61.9 51.6,60.9
S$1969
  Bottom 0.152: 51.6,60.9 50.8,60.9
S$1970
  Bottom 0.152: 50.6,61.9 49.6,60.9
S$1971
  Bottom 0.152: 49.6,60.9 49.2,60.9
S$1972
  Bottom 0.152: 48.6,61.9 47.6,60.9
S$1973
  Bottom 0.152: 46.6,61.9 46,61.3
S$1974
  Bottom 0.152: 46,61.3 46,60.9
S$1975
  Bottom 0.152: 44.6,61.9 44.4,61.7
S$1976
  Bottom 0.152: 44.4,61.7 44.4,60.9
S$1977
  Bottom 0.152: 42.6,61.9 42.8,61.7
S$1978
  Bottom 0.152: 42.8,61.7 42.8,60.9
S$1979
  Bottom 0.152: 40.6,61.9 41.2,61.3
S$1980
  Bottom 0.152: 41.2,61.3 41.2,60.9
S$1981
  Bottom 0.152: 38.6,61.9 39.6,60.9
S$1982
  Bottom 0.152: 36.6,61.9 37.6,60.9
S$1983
  Bottom 0.152: 37.6,60.9 38,60.9
S$1984
  Bottom 0.152: 34.6,61.9 35.6,60.9
S$1985
  Bottom 0.152: 35.6,60.9 36.4,60.9
S$1986
  Bottom 0.152: 37.4,55.9 36.4,56.9
S$1987
  Bottom 0.152: 36.4,56.9 34.8,56.9
S$1988
  Bottom 0.152: 35.4,55.9 34.6,55.9
S$1989
  Bottom 0.152: 34.6,55.9 33.6,56.9
S$1990
  Bottom 0.152: 33.6,56.9 33.2,56.9
S$1991
  Bottom 0.152: 33.4,55.9 32.6,55.9
S$1992
  Bottom 0.152: 32.6,55.9 31.6,56.9
S$1993
  Bottom 0.152: 31.4,55.9 31,55.9
S$1994
  Bottom 0.152: 31,55.9 30,56.9
S$1995
  Bottom 0.152: 29.4,55.9 28.4,56.9
S$1996
  Bottom 0.152: 27.4,55.9 26.8,56.5
S$1997
  Bottom 0.152: 26.8,56.5 26.8,56.9
S$1998
  Bottom 0.152: 36.4,59.9 35.8,59.9
S$1999
  Bottom 0.152: 35.8,59.9 34.8,60.9
S$2000
  Bottom 0.152: 34.8,60.9 34,60.9
S$2001
  Bottom 0.152: 34.4,59.9 33.8,59.9
S$2002
  Bottom 0.152: 33.8,59.9 32.8,60.9
S$2003
  Bottom 0.152: 32.8,60.9 32.4,60.9
S$2004
  Bottom 0.152: 32.4,59.9 31.8,59.9
S$2005
  Bottom 0.152: 31.8,59.9 30.8,60.9
S$2006
  Bottom 0.152: 30.4,59.9 30.2,59.9
S$2007
  Bottom 0.152: 30.2,59.9 29.2,60.9
S$2008
  Bottom 0.152: 28.4,59.9 27.6,60.7
S$2009
  Bottom 0.152: 27.6,60.7 27.6,60.9
S$2010
  Bottom 0.152: 52.4,59.9 53,59.9
S$2011
  Bottom 0.152: 53,59.9 54,60.9
S$2012
  Bottom 0.152: 54.4,59.9 54.6,59.9
S$2013
  Bottom 0.152: 54.6,59.9 55.6,60.9
S$2014
  Bottom 0.152: 56.4,59.9 57.2,60.7
S$2015
  Bottom 0.152: 57.2,60.7 57.2,60.9
S$2016
  Bottom 0.152: 58.4,59.9 58.8,60.3
S$2017
  Bottom 0.152: 58.8,60.3 58.8,60.9
S$2018
  Bottom 0.152: 60.4,59.9 60.4,60.9
S$2019
  Bottom 0.152: 50.4,59.9 51.4,59.9
S$2020
  Bottom 0.152: 51.4,59.9 52.4,60.9
S$2021
  Bottom 0.152: 51.4,55.9 52.4,56.9
S$2022
  Bottom 0.152: 52.4,56.9 53.2,56.9
S$2023
  Bottom 0.152: 53.4,55.9 53.8,55.9
S$2024
  Bottom 0.152: 53.8,55.9 54.8,56.9
S$2025
  Bottom 0.152: 55.4,55.9 56.4,56.9
S$2026
  Bottom 0.152: 57.4,55.9 58,56.5
S$2027
  Bottom 0.152: 58,56.5 58,56.9
S$2028
  Bottom 0.152: 59.4,55.9 59.6,56.1
S$2029
  Bottom 0.152: 59.6,56.1 59.6,56.9
S$2030
  Bottom 0.152: 61.4,55.9 61.2,56.1
S$2031
  Bottom 0.152: 61.2,56.1 61.2,56.9
S$2032
  Bottom 0.152: 63.4,55.9 62.8,56.5
S$2033
  Bottom 0.152: 62.8,56.5 62.8,56.9
S$2034
  Bottom 0.152: 65.4,55.9 64.4,56.9
S$2035
  Bottom 0.152: 67.4,55.9 67,55.9
S$2036
  Bottom 0.152: 67,55.9 66,56.9
S$2037
  Bottom 0.152: 69.4,55.9 68.6,55.9
S$2038
  Bottom 0.152: 68.6,55.9 67.6,56.9
S$2039
  Bottom 0.152: 62.4,59.9 62,60.3
S$2040
  Bottom 0.152: 62,60.3 62,60.9
S$2041
  Bottom 0.152: 64.4,59.9 63.6,60.7
S$2042
  Bottom 0.152: 63.6,60.7 63.6,60.9
S$2043
  Bottom 0.152: 66.4,59.9 66.2,59.9
S$2044
  Bottom 0.152: 66.2,59.9 65.2,60.9
S$2045
  Bottom 0.152: 68.4,59.9 67.8,59.9
S$2046
  Bottom 0.152: 67.8,59.9 66.8,60.9
S$2047
  Bottom 0.152: 70.4,57.9 69.4,56.9
S$2048
  Bottom 0.152: 69.4,56.9 68.4,56.9
S$2049
  Bottom 0.152: 68.6,61.9 69.2,61.9
S$2050
  Bottom 0.152: 69.2,61.9 70.2,60.9
S$2051
  Bottom 0.152: 70.2,60.9 70.8,60.9
S$2052
  Bottom 0.152: 70.6,61.9 71.6,60.9
S$2053
  Bottom 0.152: 71.6,60.9 72.4,60.9
S$2054
  Bottom 0.152: 72.6,61.9 73.6,60.9
S$2055
  Bottom 0.152: 73.6,60.9 74,60.9
S$2056
  Bottom 0.152: 74.6,61.9 75.6,60.9
S$2057
  Bottom 0.152: 76.6,61.9 77.2,61.3
S$2058
  Bottom 0.152: 77.2,61.3 77.2,60.9
S$2059
  Bottom 0.152: 67.6,65.9 68.6,64.9
S$2060
  Bottom 0.152: 68.6,64.9 70,64.9
S$2061
  Bottom 0.152: 69.6,65.9 70,65.9
S$2062
  Bottom 0.152: 70,65.9 71,64.9
S$2063
  Bottom 0.152: 71,64.9 71.6,64.9
S$2064
  Bottom 0.152: 71.6,65.9 72.2,65.9
S$2065
  Bottom 0.152: 72.2,65.9 73.2,64.9
S$2066
  Bottom 0.152: 73.6,65.9 73.8,65.9
S$2067
  Bottom 0.152: 73.8,65.9 74.8,64.9
S$2068
  Bottom 0.152: 75.6,65.9 76.4,65.1
S$2069
  Bottom 0.152: 76.4,65.1 76.4,64.9
S$2070
  Bottom 0.152: 69.2,60.9 68,60.9
S$2071
  Bottom 0.152: 68,60.9 67,61.9
S$2072
  Bottom 0.152: 67,61.9 66.6,61.9
S$2073
  Bottom 0.152: 102.8,59.9 102.2,59.9
S$2074
  Bottom 0.152: 102.2,59.9 101.2,60.9
S$2075
  Bottom 0.152: 100.8,59.9 100.6,59.9
S$2076
  Bottom 0.152: 100.6,59.9 99.6,60.9
S$2077
  Bottom 0.152: 98.8,59.9 98,60.7
S$2078
  Bottom 0.152: 98,60.7 98,60.9
S$2079
  Bottom 0.152: 96.8,59.9 96.4,60.3
S$2080
  Bottom 0.152: 96.4,60.3 96.4,60.9
S$2081
  Bottom 0.152: 94.8,59.9 94.8,60.9
S$2082
  Bottom 0.152: 104.8,59.9 103.8,59.9
S$2083
  Bottom 0.152: 103.8,59.9 102.8,60.9
S$2084
  Bottom 0.152: 103.8,55.9 102.8,56.9
S$2085
  Bottom 0.152: 102.8,56.9 102,56.9
S$2086
  Bottom 0.152: 101.8,55.9 101.4,55.9
S$2087
  Bottom 0.152: 101.4,55.9 100.4,56.9
S$2088
  Bottom 0.152: 99.8,55.9 98.8,56.9
S$2089
  Bottom 0.152: 97.8,55.9 97.2,56.5
S$2090
  Bottom 0.152: 97.2,56.5 97.2,56.9
S$2091
  Bottom 0.152: 95.8,55.9 95.6,56.1
S$2092
  Bottom 0.152: 95.6,56.1 95.6,56.9
S$2093
  Bottom 0.152: 93.8,55.9 94,56.1
S$2094
  Bottom 0.152: 94,56.1 94,56.9
S$2095
  Bottom 0.152: 91.8,55.9 92.4,56.5
S$2096
  Bottom 0.152: 92.4,56.5 92.4,56.9
S$2097
  Bottom 0.152: 89.8,55.9 90.8,56.9
S$2098
  Bottom 0.152: 87.8,55.9 88.2,55.9
S$2099
  Bottom 0.152: 88.2,55.9 89.2,56.9
S$2100
  Bottom 0.152: 85.8,55.9 86.6,55.9
S$2101
  Bottom 0.152: 86.6,55.9 87.6,56.9
S$2102
  Bottom 0.152: 92.8,59.9 93.2,60.3
S$2103
  Bottom 0.152: 93.2,60.3 93.2,60.9
S$2104
  Bottom 0.152: 90.8,59.9 91.6,60.7
S$2105
  Bottom 0.152: 91.6,60.7 91.6,60.9
S$2106
  Bottom 0.152: 88.8,59.9 89,59.9
S$2107
  Bottom 0.152: 89,59.9 90,60.9
S$2108
  Bottom 0.152: 86.8,59.9 87.4,59.9
S$2109
  Bottom 0.152: 87.4,59.9 88.4,60.9
S$2110
  Bottom 0.152: 84.8,57.9 85.8,56.9
S$2111
  Bottom 0.152: 85.8,56.9 86.8,56.9
S$2112
  Bottom 0.152: 86.6,61.9 86,61.9
S$2113
  Bottom 0.152: 86,61.9 85,60.9
S$2114
  Bottom 0.152: 85,60.9 84.4,60.9
S$2115
  Bottom 0.152: 84.6,61.9 83.6,60.9
S$2116
  Bottom 0.152: 83.6,60.9 82.8,60.9
S$2117
  Bottom 0.152: 82.6,61.9 81.6,60.9
S$2118
  Bottom 0.152: 81.6,60.9 81.2,60.9
S$2119
  Bottom 0.152: 80.6,61.9 79.6,60.9
S$2120
  Bottom 0.152: 78.6,61.9 78,61.3
S$2121
  Bottom 0.152: 78,61.3 78,60.9
S$2122
  Bottom 0.152: 87.6,65.9 86.6,64.9
S$2123
  Bottom 0.152: 86.6,64.9 85.2,64.9
S$2124
  Bottom 0.152: 85.6,65.9 85.2,65.9
S$2125
  Bottom 0.152: 85.2,65.9 84.2,64.9
S$2126
  Bottom 0.152: 84.2,64.9 83.6,64.9
S$2127
  Bottom 0.152: 83.6,65.9 83,65.9
S$2128
  Bottom 0.152: 83,65.9 82,64.9
S$2129
  Bottom 0.152: 81.6,65.9 81.4,65.9
S$2130
  Bottom 0.152: 81.4,65.9 80.4,64.9
S$2131
  Bottom 0.152: 79.6,65.9 78.8,65.1
S$2132
  Bottom 0.152: 78.8,65.1 78.8,64.9
S$2133
  Bottom 0.152: 86,60.9 87.2,60.9
S$2134
  Bottom 0.152: 87.2,60.9 88.2,61.9
S$2135
  Bottom 0.152: 88.2,61.9 88.6,61.9
S$2136  (2 unrouted)
  Top 0.508: 117,65.4 117,60.9 | 117,60.9 117,56.4 | 117,60.9 146,60.9 146,62.9
  Top 1.8: 118,62.4 116,62.4 | 118,65.4 117,65.4 116,65.4 | 118,59.4 116,59.4 | 118,56.4 117,56.4 116,56.4
S$2137
  Top 1.778: -52.08,57.73 -52.08,59.25
S$2138
  Top 1.778: -52.08,62.55 -52.08,64.08
S$2139
  Top 1.778: -47,57.73 -47,59.25
S$2140
  Top 1.778: -47,62.55 -47,64.08
S$2141
  Top 1.778: -41.92,57.73 -41.92,59.25
S$2142
  Top 1.778: -41.92,62.55 -41.92,64.08
S$2143
  Top 1.778: 145.92,57.73 145.92,59.25
S$2144
  Top 1.778: 145.92,62.55 145.92,64.08
S$2145
  Top 1.778: 151,57.73 151,59.25
S$2146
  Top 1.778: 151,62.55 151,64.08
S$2147
  Top 1.778: 156.08,57.73 156.08,59.25
S$2148
  Top 1.778: 156.08,62.55 156.08,64.08
S$2149  (via drill 0.2)
  other vias: 26.4,67.3
S$2150  (via drill 0.2)
  other vias: 43.4,54.5
S$2151  (via drill 0.2)
  other vias: 60.6,67.3
S$2152  (via drill 0.2)
  other vias: 77.6,54.5
S$2153  (via drill 0.2)
  other vias: 93.6,67.3
S$2154  (via drill 0.2)
  other vias: 104.8,67.3
S$2155  (via drill 0.2)
  other vias: 10.4,54.5
S$2156  (via drill 0.2)
  other vias: -0.8,54.5
S$2157
  Bottom 0.8: 61.4,73.8 61.4,72
S$2158
  Bottom 0.8: 63.4,73.8 63.4,72
S$2159
  Bottom 0.8: 60.4,76 60.4,77.8
S$2160
  Bottom 0.8: 62.4,76 62.4,77.8
S$2161
  Bottom 0.8: 57.4,73.8 57.4,72
S$2162
  Bottom 0.8: 59.4,73.8 59.4,72
S$2163
  Bottom 0.8: 58.4,76 58.4,77.8
S$2164
  Bottom 0.8: 56.4,76 56.4,77.8
S$2165
  Bottom 0.8: 55.4,73.8 55.4,72
S$2166
  Bottom 0.8: 53.4,73.8 53.4,72
S$2167
  Bottom 0.8: 54.4,76 54.4,77.8
S$2168
  Bottom 0.8: 52.4,76 52.4,77.8
S$2169
  Bottom 0.8: 51.4,73.8 51.4,72
S$2170
  Bottom 0.8: 49.4,73.8 49.4,72
S$2171
  Bottom 0.8: 50.4,76 50.4,77.8
S$2172
  Bottom 0.8: 69.4,73.8 69.4,72
S$2173
  Bottom 0.8: 71.4,73.8 71.4,72
S$2174
  Bottom 0.8: 68.4,76 68.4,77.8
S$2175
  Bottom 0.8: 70.4,76 70.4,77.8
S$2176
  Bottom 0.8: 65.4,73.8 65.4,72
S$2177
  Bottom 0.8: 67.4,73.8 67.4,72
S$2178
  Bottom 0.8: 64.4,76 64.4,77.8
S$2179
  Bottom 0.8: 66.4,76 66.4,77.8
S$2180
  Bottom 0.8: 44.6,81.8 44.6,80
S$2181
  Bottom 0.8: 46.6,81.8 46.6,80
S$2182
  Bottom 0.8: 43.6,84 43.6,85.8
S$2183
  Bottom 0.8: 45.6,84 45.6,85.8
S$2184
  Bottom 0.8: 40.6,81.8 40.6,80
S$2185
  Bottom 0.8: 42.6,81.8 42.6,80
S$2186
  Bottom 0.8: 41.6,84 41.6,85.8
S$2187
  Bottom 0.8: 39.6,84 39.6,85.8
S$2188
  Bottom 0.8: 38.6,81.8 38.6,80
S$2189
  Bottom 0.8: 36.6,81.8 36.6,80
S$2190
  Bottom 0.8: 37.6,84 37.6,85.8
S$2191
  Bottom 0.8: 35.6,84 35.6,85.8
S$2192
  Bottom 0.8: 34.6,81.8 34.6,80
S$2193
  Bottom 0.8: 32.6,81.8 32.6,80
S$2194
  Bottom 0.8: 33.6,84 33.6,85.8
S$2195
  Bottom 0.8: 52.6,81.8 52.6,80
S$2196
  Bottom 0.8: 54.6,81.8 54.6,80
S$2197
  Bottom 0.8: 51.6,84 51.6,85.8
S$2198
  Bottom 0.8: 53.6,84 53.6,85.8
S$2199
  Bottom 0.8: 48.6,81.8 48.6,80
S$2200
  Bottom 0.8: 50.6,81.8 50.6,80
S$2201
  Bottom 0.8: 47.6,84 47.6,85.8
S$2202
  Bottom 0.8: 49.6,84 49.6,85.8
S$2203
  Bottom 0.8: 27.4,73.8 27.4,72
S$2204
  Bottom 0.8: 29.4,73.8 29.4,72
S$2205
  Bottom 0.8: 26.4,76 26.4,77.8
S$2206
  Bottom 0.8: 28.4,76 28.4,77.8
S$2207
  Bottom 0.8: 23.4,73.8 23.4,72
S$2208
  Bottom 0.8: 25.4,73.8 25.4,72
S$2209
  Bottom 0.8: 24.4,76 24.4,77.8
S$2210
  Bottom 0.8: 22.4,76 22.4,77.8
S$2211
  Bottom 0.8: 21.4,73.8 21.4,72
S$2212
  Bottom 0.8: 19.4,73.8 19.4,72
S$2213
  Bottom 0.8: 20.4,76 20.4,77.8
S$2214
  Bottom 0.8: 18.4,76 18.4,77.8
S$2215
  Bottom 0.8: 17.4,73.8 17.4,72
S$2216
  Bottom 0.8: 15.4,73.8 15.4,72
S$2217
  Bottom 0.8: 16.4,76 16.4,77.8
S$2218
  Bottom 0.8: 35.4,73.8 35.4,72
S$2219
  Bottom 0.8: 37.4,73.8 37.4,72
S$2220
  Bottom 0.8: 34.4,76 34.4,77.8
S$2221
  Bottom 0.8: 36.4,76 36.4,77.8
S$2222
  Bottom 0.8: 31.4,73.8 31.4,72
S$2223
  Bottom 0.8: 33.4,73.8 33.4,72
S$2224
  Bottom 0.8: 30.4,76 30.4,77.8
S$2225
  Bottom 0.8: 32.4,76 32.4,77.8
S$2226
  Bottom 0.8: 78.6,81.8 78.6,80
S$2227
  Bottom 0.8: 80.6,81.8 80.6,80
S$2228
  Bottom 0.8: 77.6,84 77.6,85.8
S$2229
  Bottom 0.8: 79.6,84 79.6,85.8
S$2230
  Bottom 0.8: 74.6,81.8 74.6,80
S$2231
  Bottom 0.8: 76.6,81.8 76.6,80
S$2232
  Bottom 0.8: 75.6,84 75.6,85.8
S$2233
  Bottom 0.8: 73.6,84 73.6,85.8
S$2234
  Bottom 0.8: 72.6,81.8 72.6,80
S$2235
  Bottom 0.8: 70.6,81.8 70.6,80
S$2236
  Bottom 0.8: 71.6,84 71.6,85.8
S$2237
  Bottom 0.8: 69.6,84 69.6,85.8
S$2238
  Bottom 0.8: 68.6,81.8 68.6,80
S$2239
  Bottom 0.8: 66.6,81.8 66.6,80
S$2240
  Bottom 0.8: 67.6,84 67.6,85.8
S$2241
  Bottom 0.8: 86.6,81.8 86.6,80
S$2242
  Bottom 0.8: 88.6,81.8 88.6,80
S$2243
  Bottom 0.8: 85.6,84 85.6,85.8
S$2244
  Bottom 0.8: 87.6,84 87.6,85.8
S$2245
  Bottom 0.8: 82.6,81.8 82.6,80
S$2246
  Bottom 0.8: 84.6,81.8 84.6,80
S$2247
  Bottom 0.8: 81.6,84 81.6,85.8
S$2248
  Bottom 0.8: 83.6,84 83.6,85.8
S$2249
  Bottom 0.8: 10.2,81.8 10.2,80
S$2250
  Bottom 0.8: 12.2,81.8 12.2,80
S$2251
  Bottom 0.8: 9.2,84 9.2,85.8
S$2252
  Bottom 0.8: 11.2,84 11.2,85.8
S$2253
  Bottom 0.8: 6.2,81.8 6.2,80
S$2254
  Bottom 0.8: 8.2,81.8 8.2,80
S$2255
  Bottom 0.8: 7.2,84 7.2,85.8
S$2256
  Bottom 0.8: 5.2,84 5.2,85.8
S$2257
  Bottom 0.8: 4.2,81.8 4.2,80
S$2258
  Bottom 0.8: 2.2,81.8 2.2,80
S$2259
  Bottom 0.8: 3.2,84 3.2,85.8
S$2260
  Bottom 0.8: 1.2,84 1.2,85.8
S$2261
  Bottom 0.8: 0.2,81.8 0.2,80
S$2262
  Bottom 0.8: -1.8,81.8 -1.8,80
S$2263
  Bottom 0.8: -0.8,84 -0.8,85.8
S$2264
  Bottom 0.8: 18.2,81.8 18.2,80
S$2265
  Bottom 0.8: 20.2,81.8 20.2,80
S$2266
  Bottom 0.8: 17.2,84 17.2,85.8
S$2267
  Bottom 0.8: 19.2,84 19.2,85.8
S$2268
  Bottom 0.8: 14.2,81.8 14.2,80
S$2269
  Bottom 0.8: 16.2,81.8 16.2,80
S$2270
  Bottom 0.8: 13.2,84 13.2,85.8
S$2271
  Bottom 0.8: 15.2,84 15.2,85.8
S$2272
  Bottom 0.8: 95.8,73.8 95.8,72
S$2273
  Bottom 0.8: 97.8,73.8 97.8,72
S$2274
  Bottom 0.8: 94.8,76 94.8,77.8
S$2275
  Bottom 0.8: 96.8,76 96.8,77.8
S$2276
  Bottom 0.8: 91.8,73.8 91.8,72
S$2277
  Bottom 0.8: 93.8,73.8 93.8,72
S$2278
  Bottom 0.8: 92.8,76 92.8,77.8
S$2279
  Bottom 0.8: 90.8,76 90.8,77.8
S$2280
  Bottom 0.8: 89.8,73.8 89.8,72
S$2281
  Bottom 0.8: 87.8,73.8 87.8,72
S$2282
  Bottom 0.8: 88.8,76 88.8,77.8
S$2283
  Bottom 0.8: 86.8,76 86.8,77.8
S$2284
  Bottom 0.8: 85.8,73.8 85.8,72
S$2285
  Bottom 0.8: 83.8,73.8 83.8,72
S$2286
  Bottom 0.8: 84.8,76 84.8,77.8
S$2287
  Bottom 0.8: 103.8,73.8 103.8,72
S$2288
  Bottom 0.8: 105.8,73.8 105.8,72
S$2289
  Bottom 0.8: 102.8,76 102.8,77.8
S$2290
  Bottom 0.8: 104.8,76 104.8,77.8
S$2291
  Bottom 0.8: 99.8,73.8 99.8,72
S$2292
  Bottom 0.8: 101.8,73.8 101.8,72
S$2293
  Bottom 0.8: 98.8,76 98.8,77.8
S$2294
  Bottom 0.8: 100.8,76 100.8,77.8
S$2295  (via drill 0.2)
  other vias: 1.2,82.9
S$2296  (via drill 0.2)
  other vias: 2.8,82.9
S$2297  (via drill 0.2)
  other vias: 4.4,82.9
S$2298  (via drill 0.2)
  other vias: 6,82.9
S$2299  (via drill 0.2)
  other vias: 7.6,82.9
S$2300  (via drill 0.2)
  other vias: 9.2,82.9
S$2301  (via drill 0.2)
  other vias: 10.8,82.9
S$2302  (via drill 0.2)
  other vias: 12.4,82.9
S$2303  (via drill 0.2)
  other vias: 14,82.9
S$2304  (via drill 0.2)
  other vias: 15.6,82.9
S$2305  (via drill 0.2)
  other vias: 17.2,82.9
S$2306  (via drill 0.2)
  other vias: 2,78.9
S$2307  (via drill 0.2)
  other vias: 3.6,78.9
S$2308  (via drill 0.2)
  other vias: 5.2,78.9
S$2309  (via drill 0.2)
  other vias: 6.8,78.9
S$2310  (via drill 0.2)
  other vias: 8.4,78.9
S$2311  (via drill 0.2)
  other vias: 10,78.9
S$2312  (via drill 0.2)
  other vias: 11.6,78.9
S$2313  (via drill 0.2)
  other vias: 13.2,78.9
S$2314  (via drill 0.2)
  other vias: 14.8,78.9
S$2315  (via drill 0.2)
  other vias: 16.4,78.9
S$2316  (via drill 0.2)
  other vias: 18,74.9
S$2317  (via drill 0.2)
  other vias: 19.6,74.9
S$2318  (via drill 0.2)
  other vias: 21.2,74.9
S$2319  (via drill 0.2)
  other vias: 22.8,74.9
S$2320  (via drill 0.2)
  other vias: 24.4,74.9
S$2321  (via drill 0.2)
  other vias: 18.8,78.9
S$2322  (via drill 0.2)
  other vias: 20.4,78.9
S$2323  (via drill 0.2)
  other vias: 22,78.9
S$2324  (via drill 0.2)
  other vias: 23.6,78.9
S$2325  (via drill 0.2)
  other vias: 25.2,78.9
S$2326  (via drill 0.2)
  other vias: 26,74.9
S$2327  (via drill 0.2)