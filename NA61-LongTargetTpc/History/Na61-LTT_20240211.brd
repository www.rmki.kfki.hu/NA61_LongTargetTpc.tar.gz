# EAGLE board Na61-LTT_20240211 (EAGLE 9.6.2), part 4 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$3460  (via drill 0.2) (continued)
  other vias: 72.4,114.9
S$3461  (via drill 0.2)
  other vias: 70,118.9
S$3462  (via drill 0.2)
  other vias: 71.6,118.9
S$3463  (via drill 0.2)
  other vias: 73.2,118.9
S$3464  (via drill 0.2)
  other vias: 74,114.9
S$3465  (via drill 0.2)
  other vias: 74.8,118.9
S$3466  (via drill 0.2)
  other vias: 75.6,114.9
S$3467  (via drill 0.2)
  other vias: 76.4,118.9
S$3468  (via drill 0.2)
  other vias: 77.2,114.9
S$3469  (via drill 0.2)
  other vias: 102.8,114.9
S$3470  (via drill 0.2)
  other vias: 101.2,114.9
S$3471  (via drill 0.2)
  other vias: 99.6,114.9
S$3472  (via drill 0.2)
  other vias: 98,114.9
S$3473  (via drill 0.2)
  other vias: 96.4,114.9
S$3474  (via drill 0.2)
  other vias: 94.8,114.9
S$3475  (via drill 0.2)
  other vias: 93.2,114.9
S$3476  (via drill 0.2)
  other vias: 91.6,114.9
S$3477  (via drill 0.2)
  other vias: 90,114.9
S$3478  (via drill 0.2)
  other vias: 88.4,114.9
S$3479  (via drill 0.2)
  other vias: 86.8,110.9
S$3480  (via drill 0.2)
  other vias: 102,110.9
S$3481  (via drill 0.2)
  other vias: 100.4,110.9
S$3482  (via drill 0.2)
  other vias: 98.8,110.9
S$3483  (via drill 0.2)
  other vias: 97.2,110.9
S$3484  (via drill 0.2)
  other vias: 95.6,110.9
S$3485  (via drill 0.2)
  other vias: 94,110.9
S$3486  (via drill 0.2)
  other vias: 92.4,110.9
S$3487  (via drill 0.2)
  other vias: 90.8,110.9
S$3488  (via drill 0.2)
  other vias: 89.2,110.9
S$3489  (via drill 0.2)
  other vias: 87.6,110.9
S$3490  (via drill 0.2)
  other vias: 86,114.9
S$3491  (via drill 0.2)
  other vias: 84.4,114.9
S$3492  (via drill 0.2)
  other vias: 82.8,114.9
S$3493  (via drill 0.2)
  other vias: 85.2,118.9
S$3494  (via drill 0.2)
  other vias: 83.6,118.9
S$3495  (via drill 0.2)
  other vias: 82,118.9
S$3496  (via drill 0.2)
  other vias: 81.2,114.9
S$3497  (via drill 0.2)
  other vias: 80.4,118.9
S$3498  (via drill 0.2)
  other vias: 79.6,114.9
S$3499  (via drill 0.2)
  other vias: 78.8,118.9
S$3500  (via drill 0.2)
  other vias: 78,114.9
S$3501
  Bottom 0.152: -0.8,119.9 0.2,118.9
S$3502
  Bottom 0.152: 0.2,118.9 1.2,118.9
S$3503
  Bottom 0.152: 1.2,119.9 1.8,119.9
S$3504
  Bottom 0.152: 1.8,119.9 2.8,118.9
S$3505
  Bottom 0.152: 3.2,119.9 3.4,119.9
S$3506
  Bottom 0.152: 3.4,119.9 4.4,118.9
S$3507
  Bottom 0.152: 5.2,119.9 6,119.1
S$3508
  Bottom 0.152: 6,119.1 6,118.9
S$3509
  Bottom 0.152: 7.2,119.9 7.6,119.5
S$3510
  Bottom 0.152: 7.6,119.5 7.6,118.9
S$3511
  Bottom 0.152: 9.2,119.9 9.2,118.9
S$3512
  Bottom 0.152: 11.2,119.9 10.8,119.5
S$3513
  Bottom 0.152: 10.8,119.5 10.8,118.9
S$3514
  Bottom 0.152: 13.2,119.9 12.4,119.1
S$3515
  Bottom 0.152: 12.4,119.1 12.4,118.9
S$3516
  Bottom 0.152: 15.2,119.9 15,119.9
S$3517
  Bottom 0.152: 15,119.9 14,118.9
S$3518
  Bottom 0.152: 17.2,119.9 16.6,119.9
S$3519
  Bottom 0.152: 16.6,119.9 15.6,118.9
S$3520
  Bottom 0.152: 19.2,119.9 18.2,118.9
S$3521
  Bottom 0.152: 18.2,118.9 17.2,118.9
S$3522
  Bottom 0.152: 0.2,115.9 1.2,114.9
S$3523
  Bottom 0.152: 1.2,114.9 2,114.9
S$3524
  Bottom 0.152: 2.2,115.9 3.2,114.9
S$3525
  Bottom 0.152: 3.2,114.9 3.6,114.9
S$3526
  Bottom 0.152: 4.2,115.9 5.2,114.9
S$3527
  Bottom 0.152: 6.2,115.9 6.8,115.3
S$3528
  Bottom 0.152: 6.8,115.3 6.8,114.9
S$3529
  Bottom 0.152: 8.2,115.9 8.4,115.7
S$3530
  Bottom 0.152: 8.4,115.7 8.4,114.9
S$3531
  Bottom 0.152: 10.2,115.9 10,115.7
S$3532
  Bottom 0.152: 10,115.7 10,114.9
S$3533
  Bottom 0.152: 12.2,115.9 11.6,115.3
S$3534
  Bottom 0.152: 11.6,115.3 11.6,114.9
S$3535
  Bottom 0.152: 14.2,115.9 13.2,114.9
S$3536
  Bottom 0.152: 16.2,115.9 15.2,114.9
S$3537
  Bottom 0.152: 15.2,114.9 14.8,114.9
S$3538
  Bottom 0.152: 18.2,115.9 17.2,114.9
S$3539
  Bottom 0.152: 17.2,114.9 16.4,114.9
S$3540
  Bottom 0.152: 15.4,109.9 16.4,110.9
S$3541
  Bottom 0.152: 16.4,110.9 18,110.9
S$3542
  Bottom 0.152: 17.4,109.9 18.2,109.9
S$3543
  Bottom 0.152: 18.2,109.9 19.2,110.9
S$3544
  Bottom 0.152: 19.2,110.9 19.6,110.9
S$3545
  Bottom 0.152: 19.4,109.9 20.2,109.9
S$3546
  Bottom 0.152: 20.2,109.9 21.2,110.9
S$3547
  Bottom 0.152: 21.4,109.9 21.8,109.9
S$3548
  Bottom 0.152: 21.8,109.9 22.8,110.9
S$3549
  Bottom 0.152: 23.4,109.9 24.4,110.9
S$3550
  Bottom 0.152: 25.4,109.9 26,110.5
S$3551
  Bottom 0.152: 26,110.5 26,110.9
S$3552
  Bottom 0.152: 16.4,113.9 17,113.9
S$3553
  Bottom 0.152: 17,113.9 18,114.9
S$3554
  Bottom 0.152: 18,114.9 18.8,114.9
S$3555
  Bottom 0.152: 18.4,113.9 19,113.9
S$3556
  Bottom 0.152: 19,113.9 20,114.9
S$3557
  Bottom 0.152: 20,114.9 20.4,114.9
S$3558
  Bottom 0.152: 20.4,113.9 21,113.9
S$3559
  Bottom 0.152: 21,113.9 22,114.9
S$3560
  Bottom 0.152: 22.4,113.9 22.6,113.9
S$3561
  Bottom 0.152: 22.6,113.9 23.6,114.9
S$3562
  Bottom 0.152: 24.4,113.9 25.2,114.7
S$3563
  Bottom 0.152: 25.2,114.7 25.2,114.9
S$3564
  Bottom 0.152: 53.6,119.9 52.6,118.9
S$3565
  Bottom 0.152: 52.6,118.9 51.6,118.9
S$3566
  Bottom 0.152: 51.6,119.9 51,119.9
S$3567
  Bottom 0.152: 51,119.9 50,118.9
S$3568
  Bottom 0.152: 49.6,119.9 49.4,119.9
S$3569
  Bottom 0.152: 49.4,119.9 48.4,118.9
S$3570
  Bottom 0.152: 47.6,119.9 46.8,119.1
S$3571
  Bottom 0.152: 46.8,119.1 46.8,118.9
S$3572
  Bottom 0.152: 45.6,119.9 45.2,119.5
S$3573
  Bottom 0.152: 45.2,119.5 45.2,118.9
S$3574
  Bottom 0.152: 43.6,119.9 43.6,118.9
S$3575
  Bottom 0.152: 41.6,119.9 42,119.5
S$3576
  Bottom 0.152: 42,119.5 42,118.9
S$3577
  Bottom 0.152: 39.6,119.9 40.4,119.1
S$3578
  Bottom 0.152: 40.4,119.1 40.4,118.9
S$3579
  Bottom 0.152: 37.6,119.9 37.8,119.9
S$3580
  Bottom 0.152: 37.8,119.9 38.8,118.9
S$3581
  Bottom 0.152: 35.6,119.9 36.2,119.9
S$3582
  Bottom 0.152: 36.2,119.9 37.2,118.9
S$3583
  Bottom 0.152: 33.6,119.9 34.6,118.9
S$3584
  Bottom 0.152: 34.6,118.9 35.6,118.9
S$3585
  Bottom 0.152: 52.6,115.9 51.6,114.9
S$3586
  Bottom 0.152: 51.6,114.9 50.8,114.9
S$3587
  Bottom 0.152: 50.6,115.9 49.6,114.9
S$3588
  Bottom 0.152: 49.6,114.9 49.2,114.9
S$3589
  Bottom 0.152: 48.6,115.9 47.6,114.9
S$3590
  Bottom 0.152: 46.6,115.9 46,115.3
S$3591
  Bottom 0.152: 46,115.3 46,114.9
S$3592
  Bottom 0.152: 44.6,115.9 44.4,115.7
S$3593
  Bottom 0.152: 44.4,115.7 44.4,114.9
S$3594
  Bottom 0.152: 42.6,115.9 42.8,115.7
S$3595
  Bottom 0.152: 42.8,115.7 42.8,114.9
S$3596
  Bottom 0.152: 40.6,115.9 41.2,115.3
S$3597
  Bottom 0.152: 41.2,115.3 41.2,114.9
S$3598
  Bottom 0.152: 38.6,115.9 39.6,114.9
S$3599
  Bottom 0.152: 36.6,115.9 37.6,114.9
S$3600
  Bottom 0.152: 37.6,114.9 38,114.9
S$3601
  Bottom 0.152: 34.6,115.9 35.6,114.9
S$3602
  Bottom 0.152: 35.6,114.9 36.4,114.9
S$3603
  Bottom 0.152: 37.4,109.9 36.4,110.9
S$3604
  Bottom 0.152: 36.4,110.9 34.8,110.9
S$3605
  Bottom 0.152: 35.4,109.9 34.6,109.9
S$3606
  Bottom 0.152: 34.6,109.9 33.6,110.9
S$3607
  Bottom 0.152: 33.6,110.9 33.2,110.9
S$3608
  Bottom 0.152: 33.4,109.9 32.6,109.9
S$3609
  Bottom 0.152: 32.6,109.9 31.6,110.9
S$3610
  Bottom 0.152: 31.4,109.9 31,109.9
S$3611
  Bottom 0.152: 31,109.9 30,110.9
S$3612
  Bottom 0.152: 29.4,109.9 28.4,110.9
S$3613
  Bottom 0.152: 27.4,109.9 26.8,110.5
S$3614
  Bottom 0.152: 26.8,110.5 26.8,110.9
S$3615
  Bottom 0.152: 36.4,113.9 35.8,113.9
S$3616
  Bottom 0.152: 35.8,113.9 34.8,114.9
S$3617
  Bottom 0.152: 34.8,114.9 34,114.9
S$3618
  Bottom 0.152: 34.4,113.9 33.8,113.9
S$3619
  Bottom 0.152: 33.8,113.9 32.8,114.9
S$3620
  Bottom 0.152: 32.8,114.9 32.4,114.9
S$3621
  Bottom 0.152: 32.4,113.9 31.8,113.9
S$3622
  Bottom 0.152: 31.8,113.9 30.8,114.9
S$3623
  Bottom 0.152: 30.4,113.9 30.2,113.9
S$3624
  Bottom 0.152: 30.2,113.9 29.2,114.9
S$3625
  Bottom 0.152: 28.4,113.9 27.6,114.7
S$3626
  Bottom 0.152: 27.6,114.7 27.6,114.9
S$3627
  Bottom 0.152: 52.4,113.9 53,113.9
S$3628
  Bottom 0.152: 53,113.9 54,114.9
S$3629
  Bottom 0.152: 54.4,113.9 54.6,113.9
S$3630
  Bottom 0.152: 54.6,113.9 55.6,114.9
S$3631
  Bottom 0.152: 56.4,113.9 57.2,114.7
S$3632
  Bottom 0.152: 57.2,114.7 57.2,114.9
S$3633
  Bottom 0.152: 58.4,113.9 58.8,114.3
S$3634
  Bottom 0.152: 58.8,114.3 58.8,114.9
S$3635
  Bottom 0.152: 60.4,113.9 60.4,114.9
S$3636
  Bottom 0.152: 50.4,113.9 51.4,113.9
S$3637
  Bottom 0.152: 51.4,113.9 52.4,114.9
S$3638
  Bottom 0.152: 51.4,109.9 52.4,110.9
S$3639
  Bottom 0.152: 52.4,110.9 53.2,110.9
S$3640
  Bottom 0.152: 53.4,109.9 53.8,109.9
S$3641
  Bottom 0.152: 53.8,109.9 54.8,110.9
S$3642
  Bottom 0.152: 55.4,109.9 56.4,110.9
S$3643
  Bottom 0.152: 57.4,109.9 58,110.5
S$3644
  Bottom 0.152: 58,110.5 58,110.9
S$3645
  Bottom 0.152: 59.4,109.9 59.6,110.1
S$3646
  Bottom 0.152: 59.6,110.1 59.6,110.9
S$3647
  Bottom 0.152: 61.4,109.9 61.2,110.1
S$3648
  Bottom 0.152: 61.2,110.1 61.2,110.9
S$3649
  Bottom 0.152: 63.4,109.9 62.8,110.5
S$3650
  Bottom 0.152: 62.8,110.5 62.8,110.9
S$3651
  Bottom 0.152: 65.4,109.9 64.4,110.9
S$3652
  Bottom 0.152: 67.4,109.9 67,109.9
S$3653
  Bottom 0.152: 67,109.9 66,110.9
S$3654
  Bottom 0.152: 69.4,109.9 68.6,109.9
S$3655
  Bottom 0.152: 68.6,109.9 67.6,110.9
S$3656
  Bottom 0.152: 62.4,113.9 62,114.3
S$3657
  Bottom 0.152: 62,114.3 62,114.9
S$3658
  Bottom 0.152: 64.4,113.9 63.6,114.7
S$3659
  Bottom 0.152: 63.6,114.7 63.6,114.9
S$3660
  Bottom 0.152: 66.4,113.9 66.2,113.9
S$3661
  Bottom 0.152: 66.2,113.9 65.2,114.9
S$3662
  Bottom 0.152: 68.4,113.9 67.8,113.9
S$3663
  Bottom 0.152: 67.8,113.9 66.8,114.9
S$3664
  Bottom 0.152: 70.4,111.9 69.4,110.9
S$3665
  Bottom 0.152: 69.4,110.9 68.4,110.9
S$3666
  Bottom 0.152: 68.6,115.9 69.2,115.9
S$3667
  Bottom 0.152: 69.2,115.9 70.2,114.9
S$3668
  Bottom 0.152: 70.2,114.9 70.8,114.9
S$3669
  Bottom 0.152: 70.6,115.9 71.6,114.9
S$3670
  Bottom 0.152: 71.6,114.9 72.4,114.9
S$3671
  Bottom 0.152: 72.6,115.9 73.6,114.9
S$3672
  Bottom 0.152: 73.6,114.9 74,114.9
S$3673
  Bottom 0.152: 74.6,115.9 75.6,114.9
S$3674
  Bottom 0.152: 76.6,115.9 77.2,115.3
S$3675
  Bottom 0.152: 77.2,115.3 77.2,114.9
S$3676
  Bottom 0.152: 67.6,119.9 68.6,118.9
S$3677
  Bottom 0.152: 68.6,118.9 70,118.9
S$3678
  Bottom 0.152: 69.6,119.9 70,119.9
S$3679
  Bottom 0.152: 70,119.9 71,118.9
S$3680
  Bottom 0.152: 71,118.9 71.6,118.9
S$3681
  Bottom 0.152: 71.6,119.9 72.2,119.9
S$3682
  Bottom 0.152: 72.2,119.9 73.2,118.9
S$3683
  Bottom 0.152: 73.6,119.9 73.8,119.9
S$3684
  Bottom 0.152: 73.8,119.9 74.8,118.9
S$3685
  Bottom 0.152: 75.6,119.9 76.4,119.1
S$3686
  Bottom 0.152: 76.4,119.1 76.4,118.9
S$3687
  Bottom 0.152: 69.2,114.9 68,114.9
S$3688
  Bottom 0.152: 68,114.9 67,115.9
S$3689
  Bottom 0.152: 67,115.9 66.6,115.9
S$3690
  Bottom 0.152: 102.8,113.9 102.2,113.9
S$3691
  Bottom 0.152: 102.2,113.9 101.2,114.9
S$3692
  Bottom 0.152: 100.8,113.9 100.6,113.9
S$3693
  Bottom 0.152: 100.6,113.9 99.6,114.9
S$3694
  Bottom 0.152: 98.8,113.9 98,114.7
S$3695
  Bottom 0.152: 98,114.7 98,114.9
S$3696
  Bottom 0.152: 96.8,113.9 96.4,114.3
S$3697
  Bottom 0.152: 96.4,114.3 96.4,114.9
S$3698
  Bottom 0.152: 94.8,113.9 94.8,114.9
S$3699
  Bottom 0.152: 104.8,113.9 103.8,113.9
S$3700
  Bottom 0.152: 103.8,113.9 102.8,114.9
S$3701
  Bottom 0.152: 103.8,109.9 102.8,110.9
S$3702
  Bottom 0.152: 102.8,110.9 102,110.9
S$3703
  Bottom 0.152: 101.8,109.9 101.4,109.9
S$3704
  Bottom 0.152: 101.4,109.9 100.4,110.9
S$3705
  Bottom 0.152: 99.8,109.9 98.8,110.9
S$3706
  Bottom 0.152: 97.8,109.9 97.2,110.5
S$3707
  Bottom 0.152: 97.2,110.5 97.2,110.9
S$3708
  Bottom 0.152: 95.8,109.9 95.6,110.1
S$3709
  Bottom 0.152: 95.6,110.1 95.6,110.9
S$3710
  Bottom 0.152: 93.8,109.9 94,110.1
S$3711
  Bottom 0.152: 94,110.1 94,110.9
S$3712
  Bottom 0.152: 91.8,109.9 92.4,110.5
S$3713
  Bottom 0.152: 92.4,110.5 92.4,110.9
S$3714
  Bottom 0.152: 89.8,109.9 90.8,110.9
S$3715
  Bottom 0.152: 87.8,109.9 88.2,109.9
S$3716
  Bottom 0.152: 88.2,109.9 89.2,110.9
S$3717
  Bottom 0.152: 85.8,109.9 86.6,109.9
S$3718
  Bottom 0.152: 86.6,109.9 87.6,110.9
S$3719
  Bottom 0.152: 92.8,113.9 93.2,114.3
S$3720
  Bottom 0.152: 93.2,114.3 93.2,114.9
S$3721
  Bottom 0.152: 90.8,113.9 91.6,114.7
S$3722
  Bottom 0.152: 91.6,114.7 91.6,114.9
S$3723
  Bottom 0.152: 88.8,113.9 89,113.9
S$3724
  Bottom 0.152: 89,113.9 90,114.9
S$3725
  Bottom 0.152: 86.8,113.9 87.4,113.9
S$3726
  Bottom 0.152: 87.4,113.9 88.4,114.9
S$3727
  Bottom 0.152: 84.8,111.9 85.8,110.9
S$3728
  Bottom 0.152: 85.8,110.9 86.8,110.9
S$3729
  Bottom 0.152: 86.6,115.9 86,115.9
S$3730
  Bottom 0.152: 86,115.9 85,114.9
S$3731
  Bottom 0.152: 85,114.9 84.4,114.9
S$3732
  Bottom 0.152: 84.6,115.9 83.6,114.9
S$3733
  Bottom 0.152: 83.6,114.9 82.8,114.9
S$3734
  Bottom 0.152: 82.6,115.9 81.6,114.9
S$3735
  Bottom 0.152: 81.6,114.9 81.2,114.9
S$3736
  Bottom 0.152: 80.6,115.9 79.6,114.9
S$3737
  Bottom 0.152: 78.6,115.9 78,115.3
S$3738
  Bottom 0.152: 78,115.3 78,114.9
S$3739
  Bottom 0.152: 87.6,119.9 86.6,118.9
S$3740
  Bottom 0.152: 86.6,118.9 85.2,118.9
S$3741
  Bottom 0.152: 85.6,119.9 85.2,119.9
S$3742
  Bottom 0.152: 85.2,119.9 84.2,118.9
S$3743
  Bottom 0.152: 84.2,118.9 83.6,118.9
S$3744
  Bottom 0.152: 83.6,119.9 83,119.9
S$3745
  Bottom 0.152: 83,119.9 82,118.9
S$3746
  Bottom 0.152: 81.6,119.9 81.4,119.9
S$3747
  Bottom 0.152: 81.4,119.9 80.4,118.9
S$3748
  Bottom 0.152: 79.6,119.9 78.8,119.1
S$3749
  Bottom 0.152: 78.8,119.1 78.8,118.9
S$3750
  Bottom 0.152: 86,114.9 87.2,114.9
S$3751
  Bottom 0.152: 87.2,114.9 88.2,115.9
S$3752
  Bottom 0.152: 88.2,115.9 88.6,115.9
S$3753  (2 unrouted)
  Top 0.508: 117,119.4 117,114.9 | 117,114.9 117,110.4 | 117,114.9 146,114.9 146,116.9
  Top 1.8: 118,116.4 116,116.4 | 118,119.4 117,119.4 116,119.4 | 118,113.4 116,113.4 | 118,110.4 117,110.4 116,110.4
S$3754
  Top 1.778: -52.08,111.73 -52.08,113.25
S$3755
  Top 1.778: -52.08,116.55 -52.08,118.08
S$3756
  Top 1.778: -47,111.73 -47,113.25
S$3757
  Top 1.778: -47,116.55 -47,118.08
S$3758
  Top 1.778: -41.92,111.73 -41.92,113.25
S$3759
  Top 1.778: -41.92,116.55 -41.92,118.08
S$3760
  Top 1.778: 145.92,111.73 145.92,113.25
S$3761
  Top 1.778: 145.92,116.55 145.92,118.08
S$3762
  Top 1.778: 151,111.73 151,113.25
S$3763
  Top 1.778: 151,116.55 151,118.08
S$3764
  Top 1.778: 156.08,111.73 156.08,113.25
S$3765
  Top 1.778: 156.08,116.55 156.08,118.08
S$3766  (via drill 0.2)
  other vias: 26.4,121.3
S$3767  (via drill 0.2)
  other vias: 43.4,108.5
S$3768  (via drill 0.2)
  other vias: 60.6,121.3
S$3769  (via drill 0.2)
  other vias: 77.6,108.5
S$3770  (via drill 0.2)
  other vias: 93.6,121.3
S$3771  (via drill 0.2)
  other vias: 104.8,121.3
S$3772  (via drill 0.2)
  other vias: 10.4,108.5
S$3773  (via drill 0.2)
  other vias: -0.8,108.5
S$3774
  Bottom 0.8: 61.4,127.8 61.4,126
S$3775
  Bottom 0.8: 63.4,127.8 63.4,126
S$3776
  Bottom 0.8: 60.4,130 60.4,131.8
S$3777
  Bottom 0.8: 62.4,130 62.4,131.8
S$3778
  Bottom 0.8: 57.4,127.8 57.4,126
S$3779
  Bottom 0.8: 59.4,127.8 59.4,126
S$3780
  Bottom 0.8: 58.4,130 58.4,131.8
S$3781
  Bottom 0.8: 56.4,130 56.4,131.8
S$3782
  Bottom 0.8: 55.4,127.8 55.4,126
S$3783
  Bottom 0.8: 53.4,127.8 53.4,126
S$3784
  Bottom 0.8: 54.4,130 54.4,131.8
S$3785
  Bottom 0.8: 52.4,130 52.4,131.8
S$3786
  Bottom 0.8: 51.4,127.8 51.4,126
S$3787
  Bottom 0.8: 49.4,127.8 49.4,126
S$3788
  Bottom 0.8: 50.4,130 50.4,131.8
S$3789
  Bottom 0.8: 69.4,127.8 69.4,126
S$3790
  Bottom 0.8: 71.4,127.8 71.4,126
S$3791
  Bottom 0.8: 68.4,130 68.4,131.8
S$3792
  Bottom 0.8: 70.4,130 70.4,131.8
S$3793
  Bottom 0.8: 65.4,127.8 65.4,126
S$3794
  Bottom 0.8: 67.4,127.8 67.4,126
S$3795
  Bottom 0.8: 64.4,130 64.4,131.8
S$3796
  Bottom 0.8: 66.4,130 66.4,131.8
S$3797
  Bottom 0.8: 44.6,135.8 44.6,134
S$3798
  Bottom 0.8: 46.6,135.8 46.6,134
S$3799
  Bottom 0.8: 43.6,138 43.6,139.8
S$3800
  Bottom 0.8: 45.6,138 45.6,139.8
S$3801
  Bottom 0.8: 40.6,135.8 40.6,134
S$3802
  Bottom 0.8: 42.6,135.8 42.6,134
S$3803
  Bottom 0.8: 41.6,138 41.6,139.8
S$3804
  Bottom 0.8: 39.6,138 39.6,139.8
S$3805
  Bottom 0.8: 38.6,135.8 38.6,134
S$3806
  Bottom 0.8: 36.6,135.8 36.6,134
S$3807
  Bottom 0.8: 37.6,138 37.6,139.8
S$3808
  Bottom 0.8: 35.6,138 35.6,139.8
S$3809
  Bottom 0.8: 34.6,135.8 34.6,134
S$3810
  Bottom 0.8: 32.6,135.8 32.6,134
S$3811
  Bottom 0.8: 33.6,138 33.6,139.8
S$3812
  Bottom 0.8: 52.6,135.8 52.6,134
S$3813
  Bottom 0.8: 54.6,135.8 54.6,134
S$3814
  Bottom 0.8: 51.6,138 51.6,139.8
S$3815
  Bottom 0.8: 53.6,138 53.6,139.8
S$3816
  Bottom 0.8: 48.6,135.8 48.6,134
S$3817
  Bottom 0.8: 50.6,135.8 50.6,134
S$3818
  Bottom 0.8: 47.6,138 47.6,139.8
S$3819
  Bottom 0.8: 49.6,138 49.6,139.8
S$3820
  Bottom 0.8: 27.4,127.8 27.4,126
S$3821
  Bottom 0.8: 29.4,127.8 29.4,126
S$3822
  Bottom 0.8: 26.4,130 26.4,131.8
S$3823
  Bottom 0.8: 28.4,130 28.4,131.8
S$3824
  Bottom 0.8: 23.4,127.8 23.4,126
S$3825
  Bottom 0.8: 25.4,127.8 25.4,126
S$3826
  Bottom 0.8: 24.4,130 24.4,131.8
S$3827
  Bottom 0.8: 22.4,130 22.4,131.8
S$3828
  Bottom 0.8: 21.4,127.8 21.4,126
S$3829
  Bottom 0.8: 19.4,127.8 19.4,126
S$3830
  Bottom 0.8: 20.4,130 20.4,131.8
S$3831
  Bottom 0.8: 18.4,130 18.4,131.8
S$3832
  Bottom 0.8: 17.4,127.8 17.4,126
S$3833
  Bottom 0.8: 15.4,127.8 15.4,126
S$3834
  Bottom 0.8: 16.4,130 16.4,131.8
S$3835
  Bottom 0.8: 35.4,127.8 35.4,126
S$3836
  Bottom 0.8: 37.4,127.8 37.4,126
S$3837
  Bottom 0.8: 34.4,130 34.4,131.8
S$3838
  Bottom 0.8: 36.4,130 36.4,131.8
S$3839
  Bottom 0.8: 31.4,127.8 31.4,126
S$3840
  Bottom 0.8: 33.4,127.8 33.4,126
S$3841
  Bottom 0.8: 30.4,130 30.4,131.8
S$3842
  Bottom 0.8: 32.4,130 32.4,131.8
S$3843
  Bottom 0.8: 78.6,135.8 78.6,134
S$3844
  Bottom 0.8: 80.6,135.8 80.6,134
S$3845
  Bottom 0.8: 77.6,138 77.6,139.8
S$3846
  Bottom 0.8: 79.6,138 79.6,139.8
S$3847
  Bottom 0.8: 74.6,135.8 74.6,134
S$3848
  Bottom 0.8: 76.6,135.8 76.6,134
S$3849
  Bottom 0.8: 75.6,138 75.6,139.8
S$3850
  Bottom 0.8: 73.6,138 73.6,139.8
S$3851
  Bottom 0.8: 72.6,135.8 72.6,134
S$3852
  Bottom 0.8: 70.6,135.8 70.6,134
S$3853
  Bottom 0.8: 71.6,138 71.6,139.8
S$3854
  Bottom 0.8: 69.6,138 69.6,139.8
S$3855
  Bottom 0.8: 68.6,135.8 68.6,134
S$3856
  Bottom 0.8: 66.6,135.8 66.6,134
S$3857
  Bottom 0.8: 67.6,138 67.6,139.8
S$3858
  Bottom 0.8: 86.6,135.8 86.6,134
S$3859
  Bottom 0.8: 88.6,135.8 88.6,134
S$3860
  Bottom 0.8: 85.6,138 85.6,139.8
S$3861
  Bottom 0.8: 87.6,138 87.6,139.8
S$3862
  Bottom 0.8: 82.6,135.8 82.6,134
S$3863
  Bottom 0.8: 84.6,135.8 84.6,134
S$3864
  Bottom 0.8: 81.6,138 81.6,139.8
S$3865
  Bottom 0.8: 83.6,138 83.6,139.8
S$3866
  Bottom 0.8: 10.2,135.8 10.2,134
S$3867
  Bottom 0.8: 12.2,135.8 12.2,134
S$3868
  Bottom 0.8: 9.2,138 9.2,139.8
S$3869
  Bottom 0.8: 11.2,138 11.2,139.8
S$3870
  Bottom 0.8: 6.2,135.8 6.2,134
S$3871
  Bottom 0.8: 8.2,135.8 8.2,134
S$3872
  Bottom 0.8: 7.2,138 7.2,139.8
S$3873
  Bottom 0.8: 5.2,138 5.2,139.8
S$3874
  Bottom 0.8: 4.2,135.8 4.2,134
S$3875
  Bottom 0.8: 2.2,135.8 2.2,134
S$3876
  Bottom 0.8: 3.2,138 3.2,139.8
S$3877
  Bottom 0.8: 1.2,138 1.2,139.8
S$3878
  Bottom 0.8: 0.2,135.8 0.2,134
S$3879
  Bottom 0.8: -1.8,135.8 -1.8,134
S$3880
  Bottom 0.8: -0.8,138 -0.8,139.8
S$3881
  Bottom 0.8: 18.2,135.8 18.2,134
S$3882
  Bottom 0.8: 20.2,135.8 20.2,134
S$3883
  Bottom 0.8: 17.2,138 17.2,139.8
S$3884
  Bottom 0.8: 19.2,138 19.2,139.8
S$3885
  Bottom 0.8: 14.2,135.8 14.2,134
S$3886
  Bottom 0.8: 16.2,135.8 16.2,134
S$3887
  Bottom 0.8: 13.2,138 13.2,139.8
S$3888
  Bottom 0.8: 15.2,138 15.2,139.8
S$3889
  Bottom 0.8: 95.8,127.8 95.8,126
S$3890
  Bottom 0.8: 97.8,127.8 97.8,126
S$3891
  Bottom 0.8: 94.8,130 94.8,131.8
S$3892
  Bottom 0.8: 96.8,130 96.8,131.8
S$3893
  Bottom 0.8: 91.8,127.8 91.8,126
S$3894
  Bottom 0.8: 93.8,127.8 93.8,126
S$3895
  Bottom 0.8: 92.8,130 92.8,131.8
S$3896
  Bottom 0.8: 90.8,130 90.8,131.8
S$3897
  Bottom 0.8: 89.8,127.8 89.8,126
S$3898
  Bottom 0.8: 87.8,127.8 87.8,126
S$3899
  Bottom 0.8: 88.8,130 88.8,131.8
S$3900
  Bottom 0.8: 86.8,130 86.8,131.8
S$3901
  Bottom 0.8: 85.8,127.8 85.8,126
S$3902
  Bottom 0.8: 83.8,127.8 83.8,126
S$3903
  Bottom 0.8: 84.8,130 84.8,131.8
S$3904
  Bottom 0.8: 103.8,127.8 103.8,126
S$3905
  Bottom 0.8: 105.8,127.8 105.8,126
S$3906
  Bottom 0.8: 102.8,130 102.8,131.8
S$3907
  Bottom 0.8: 104.8,130 104.8,131.8
S$3908
  Bottom 0.8: 99.8,127.8 99.8,126
S$3909
  Bottom 0.8: 101.8,127.8 101.8,126
S$3910
  Bottom 0.8: 98.8,130 98.8,131.8
S$3911
  Bottom 0.8: 100.8,130 100.8,131.8
S$3912  (via drill 0.2)
  other vias: 1.2,136.9
S$3913  (via drill 0.2)
  other vias: 2.8,136.9
S$3914  (via drill 0.2)
  other vias: 4.4,136.9
S$3915  (via drill 0.2)
  other vias: 6,136.9
S$3916  (via drill 0.2)
  other vias: 7.6,136.9
S$3917  (via drill 0.2)
  other vias: 9.2,136.9
S$3918  (via drill 0.2)
  other vias: 10.8,136.9
S$3919  (via drill 0.2)
  other vias: 12.4,136.9
S$3920  (via drill 0.2)
  other vias: 14,136.9
S$3921  (via drill 0.2)
  other vias: 15.6,136.9
S$3922  (via drill 0.2)
  other vias: 17.2,136.9
S$3923  (via drill 0.2)
  other vias: 2,132.9
S$3924  (via drill 0.2)
  other vias: 3.6,132.9
S$3925  (via drill 0.2)
  other vias: 5.2,132.9
S$3926  (via drill 0.2)
  other vias: 6.8,132.9
S$3927  (via drill 0.2)
  other vias: 8.4,132.9
S$3928  (via drill 0.2)
  other vias: 10,132.9
S$3929  (via drill 0.2)
  other vias: 11.6,132.9
S$3930  (via drill 0.2)
  other vias: 13.2,132.9
S$3931  (via drill 0.2)
  other vias: 14.8,132.9
S$3932  (via drill 0.2)
  other vias: 16.4,132.9
S$3933  (via drill 0.2)
  other vias: 18,128.9
S$3934  (via drill 0.2)
  other vias: 19.6,128.9
S$3935  (via drill 0.2)
  other vias: 21.2,128.9
S$3936  (via drill 0.2)
  other vias: 22.8,128.9
S$3937  (via drill 0.2)
  other vias: 24.4,128.9
S$3938  (via drill 0.2)
  other vias: 18.8,132.9
S$3939  (via drill 0.2)
  other vias: 20.4,132.9
S$3940  (via drill 0.2)
  other vias: 22,132.9
S$3941  (via drill 0.2)
  other vias: 23.6,132.9
S$3942  (via drill 0.2)
  other vias: 25.2,132.9
S$3943  (via drill 0.2)
  other vias: 26,128.9
S$3944  (via drill 0.2)
  other vias: 51.6,136.9
S$3945  (via drill 0.2)
  other vias: 50,136.9
S$3946  (via drill 0.2)
  other vias: 48.4,136.9
S$3947  (via drill 0.2)
  other vias: 46.8,136.9
S$3948  (via drill 0.2)
  other vias: 45.2,136.9
S$3949  (via drill 0.2)
  other vias: 43.6,136.9
S$3950  (via drill 0.2)
  other vias: 42,136.9
S$3951  (via drill 0.2)
  other vias: 40.4,136.9
S$3952  (via drill 0.2)
  other vias: 38.8,136.9
S$3953  (via drill 0.2)
  other vias: 37.2,136.9
S$3954  (via drill 0.2)
  other vias: 35.6,136.9
S$3955  (via drill 0.2)
  other vias: 50.8,132.9
S$3956  (via drill 0.2)
  other vias: 49.2,132.9
S$3957  (via drill 0.2)
  other vias: 47.6,132.9
S$3958  (via drill 0.2)
  other vias: 46,132.9
S$3959  (via drill 0.2)
  other vias: 44.4,132.9
S$3960  (via drill 0.2)
  other vias: 42.8,132.9
S$3961  (via drill 0.2)
  other vias: 41.2,132.9
S$3962  (via drill 0.2)
  other vias: 39.6,132.9
S$3963  (via drill 0.2)
  other vias: 38,132.9
S$3964  (via drill 0.2)
  other vias: 36.4,132.9
S$3965  (via drill 0.2)
  other vias: 34.8,128.9
S$3966  (via drill 0.2)
  other vias: 33.2,128.9
S$3967  (via drill 0.2)
  other vias: 31.6,128.9
S$3968  (via drill 0.2)
  other vias: 30,128.9
S$3969  (via drill 0.2)
  other vias: 28.4,128.9
S$3970  (via drill 0.2)
  other vias: 34,132.9
S$3971  (via drill 0.2)
  other vias: 32.4,132.9
S$3972  (via drill 0.2)
  other vias: 30.8,132.9
S$3973  (via drill 0.2)
  other vias: 29.2,132.9
S$3974  (via drill 0.2)
  other vias: 27.6,132.9
S$3975  (via drill 0.2)
  other vias: 26.8,128.9
S$3976  (via drill 0.2)
  other vias: 52.4,132.9
S$3977  (via drill 0.2)
  other vias: 54,132.9
S$3978  (via drill 0.2)
  other vias: 55.6,132.9
S$3979  (via drill 0.2)
  other vias: 57.2,132.9
S$3980  (via drill 0.2)
  other vias: 58.8,132.9
S$3981  (via drill 0.2)
  other vias: 60.4,132.9
S$3982  (via drill 0.2)
  other vias: 62,132.9
S$3983  (via drill 0.2)
  other vias: 63.6,132.9
S$3984  (via drill 0.2)
  other vias: 65.2,132.9
S$3985  (via drill 0.2)
  other vias: 66.8,132.9
S$3986  (via drill 0.2)
  other vias: 68.4,128.9
S$3987  (via drill 0.2)
  other vias: 53.2,128.9
S$3988  (via drill 0.2)
  other vias: 54.8,128.9
S$3989  (via drill 0.2)
  other vias: 56.4,128.9
S$3990  (via drill 0.2)
  other vias: 58,128.9
S$3991  (via drill 0.2)
  other vias: 59.6,128.9
S$3992  (via drill 0.2)
  other vias: 61.2,128.9
S$3993  (via drill 0.2)
  other vias: 62.8,128.9
S$3994  (via drill 0.2)
  other vias: 64.4,128.9
S$3995  (via drill 0.2)
  other vias: 66,128.9
S$3996  (via drill 0.2)
  other vias: 67.6,128.9
S$3997  (via drill 0.2)
  other vias: 69.2,132.9
S$3998  (via drill 0.2)
  other vias: 70.8,132.9
S$3999  (via drill 0.2)
  other vias: 72.4,132.9
S$4000  (via drill 0.2)
  other vias: 70,136.9
S$4001  (via drill 0.2)
  other vias: 71.6,136.9
S$4002  (via drill 0.2)
  other vias: 73.2,136.9
S$4003  (via drill 0.2)
  other vias: 74,132.9
S$4004  (via drill 0.2)
  other vias: 74.8,136.9
S$4005  (via drill 0.2)
  other vias: 75.6,132.9
S$4006  (via drill 0.2)
  other vias: 76.4,136.9
S$4007  (via drill 0.2)
  other vias: 77.2,132.9
S$4008  (via drill 0.2)
  other vias: 102.8,132.9
S$4009  (via drill 0.2)
  other vias: 101.2,132.9
S$4010  (via drill 0.2)
  other vias: 99.6,132.9
S$4011  (via drill 0.2)
  other vias: 98,132.9
S$4012  (via drill 0.2)
  other vias: 96.4,132.9
S$4013  (via drill 0.2)
  other vias: 94.8,132.9
S$4014  (via drill 0.2)
  other vias: 93.2,132.9
S$4015  (via drill 0.2)
  other vias: 91.6,132.9
S$4016  (via drill 0.2)
  other vias: 90,132.9
S$4017  (via drill 0.2)
  other vias: 88.4,132.9
S$4018  (via drill 0.2)
  other vias: 86.8,128.9
S$4019  (via drill 0.2)
  other vias: 102,128.9
S$4020  (via drill 0.2)
  other vias: 100.4,128.9
S$4021  (via drill 0.2)
  other vias: 98.8,128.9
S$4022  (via drill 0.2)
  other vias: 97.2,128.9
S$4023  (via drill 0.2)
  other vias: 95.6,128.9
S$4024  (via drill 0.2)
  other vias: 94,128.9
S$4025  (via drill 0.2)
  other vias: 92.4,128.9
S$4026  (via drill 0.2)
  other vias: 90.8,128.9
S$4027  (via drill 0.2)
  other vias: 89.2,128.9
S$4028  (via drill 0.2)
  other vias: 87.6,128.9
S$4029  (via drill 0.2)
  other vias: 86,132.9
S$4030  (via drill 0.2)
  other vias: 84.4,132.9
S$4031  (via drill 0.2)
  other vias: 82.8,132.9
S$4032  (via drill 0.2)
  other vias: 85.2,136.9
S$4033  (via drill 0.2)
  other vias: 83.6,136.9
S$4034  (via drill 0.2)
  other vias: 82,136.9
S$4035  (via drill 0.2)
  other vias: 81.2,132.9
S$4036  (via drill 0.2)
  other vias: 80.4,136.9
S$4037  (via drill 0.2)
  other vias: 79.6,132.9
S$4038  (via drill 0.2)
  other vias: 78.8,136.9
S$4039  (via drill 0.2)
  other vias: 78,132.9
S$4040
  Bottom 0.152: -0.8,137.9 0.2,136.9
S$4041
  Bottom 0.152: 0.2,136.9 1.2,136.9
S$4042
  Bottom 0.152: 1.2,137.9 1.8,137.9
S$4043
  Bottom 0.152: 1.8,137.9 2.8,136.9
S$4044
  Bottom 0.152: 3.2,137.9 3.4,137.9
S$4045
  Bottom 0.152: 3.4,137.9 4.4,136.9
S$4046
  Bottom 0.152: 5.2,137.9 6,137.1
S$4047
  Bottom 0.152: 6,137.1 6,136.9
S$4048
  Bottom 0.152: 7.2,137.9 7.6,137.5
S$4049
  Bottom 0.152: 7.6,137.5 7.6,136.9
S$4050
  Bottom 0.152: 9.2,137.9 9.2,136.9
S$4051
  Bottom 0.152: 11.2,137.9 10.8,137.5
S$4052
  Bottom 0.152: 10.8,137.5 10.8,136.9
S$4053
  Bottom 0.152: 13.2,137.9 12.4,137.1
S$4054
  Bottom 0.152: 12.4,137.1 12.4,136.9
S$4055
  Bottom 0.152: 15.2,137.9 15,137.9
S$4056
  Bottom 0.152: 15,137.9 14,136.9
S$4057
  Bottom 0.152: 17.2,137.9 16.6,137.9
S$4058
  Bottom 0.152: 16.6,137.9 15.6,136.9
S$4059
  Bottom 0.152: 19.2,137.9 18.2,136.9
S$4060
  Bottom 0.152: 18.2,136.9 17.2,136.9
S$4061
  Bottom 0.152: 0.2,133.9 1.2,132.9
S$4062
  Bottom 0.152: 1.2,132.9 2,132.9
S$4063
  Bottom 0.152: 2.2,133.9 3.2,132.9
S$4064
  Bottom 0.152: 3.2,132.9 3.6,132.9
S$4065
  Bottom 0.152: 4.2,133.9 5.2,132.9
S$4066
  Bottom 0.152: 6.2,133.9 6.8,133.3
S$4067
  Bottom 0.152: 6.8,133.3 6.8,132.9
S$4068
  Bottom 0.152: 8.2,133.9 8.4,133.7
S$4069
  Bottom 0.152: 8.4,133.7 8.4,132.9
S$4070
  Bottom 0.152: 10.2,133.9 10,133.7
S$4071
  Bottom 0.152: 10,133.7 10,132.9
S$4072
  Bottom 0.152: 12.2,133.9 11.6,133.3
S$4073
  Bottom 0.152: 11.6,133.3 11.6,132.9
S$4074
  Bottom 0.152: 14.2,133.9 13.2,132.9
S$4075
  Bottom 0.152: 16.2,133.9 15.2,132.9
S$4076
  Bottom 0.152: 15.2,132.9 14.8,132.9
S$4077
  Bottom 0.152: 18.2,133.9 17.2,132.9
S$4078
  Bottom 0.152: 17.2,132.9 16.4,132.9
S$4079
  Bottom 0.152: 15.4,127.9 16.4,128.9
S$4080
  Bottom 0.152: 16.4,128.9 18,128.9
S$4081
  Bottom 0.152: 17.4,127.9 18.2,127.9
S$4082
  Bottom 0.152: 18.2,127.9 19.2,128.9
S$4083
  Bottom 0.152: 19.2,128.9 19.6,128.9
S$4084
  Bottom 0.152: 19.4,127.9 20.2,127.9
S$4085
  Bottom 0.152: 20.2,127.9 21.2,128.9
S$4086
  Bottom 0.152: 21.4,127.9 21.8,127.9
S$4087
  Bottom 0.152: 21.8,127.9 22.8,128.9
S$4088
  Bottom 0.152: 23.4,127.9 24.4,128.9
S$4089
  Bottom 0.152: 25.4,127.9 26,128.5
S$4090
  Bottom 0.152: 26,128.5 26,128.9
S$4091
  Bottom 0.152: 16.4,131.9 17,131.9
S$4092
  Bottom 0.152: 17,131.9 18,132.9
S$4093
  Bottom 0.152: 18,132.9 18.8,132.9
S$4094
  Bottom 0.152: 18.4,131.9 19,131.9
S$4095
  Bottom 0.152: 19,131.9 20,132.9
S$4096
  Bottom 0.152: 20,132.9 20.4,132.9
S$4097
  Bottom 0.152: 20.4,131.9 21,131.9
S$4098
  Bottom 0.152: 21,131.9 22,132.9
S$4099
  Bottom 0.152: 22.4,131.9 22.6,131.9
S$4100
  Bottom 0.152: 22.6,131.9 23.6,132.9
S$4101
  Bottom 0.152: 24.4,131.9 25.2,132.7
S$4102
  Bottom 0.152: 25.2,132.7 25.2,132.9
S$4103
  Bottom 0.152: 53.6,137.9 52.6,136.9
S$4104
  Bottom 0.152: 52.6,136.9 51.6,136.9
S$4105
  Bottom 0.152: 51.6,137.9 51,137.9
S$4106
  Bottom 0.152: 51,137.9 50,136.9
S$4107
  Bottom 0.152: 49.6,137.9 49.4,137.9
S$4108
  Bottom 0.152: 49.4,137.9 48.4,136.9
S$4109
  Bottom 0.152: 47.6,137.9 46.8,137.1
S$4110
  Bottom 0.152: 46.8,137.1 46.8,136.9
S$4111
  Bottom 0.152: 45.6,137.9 45.2,137.5
S$4112
  Bottom 0.152: 45.2,137.5 45.2,136.9
S$4113
  Bottom 0.152: 43.6,137.9 43.6,136.9
S$4114
  Bottom 0.152: 41.6,137.9 42,137.5
S$4115
  Bottom 0.152: 42,137.5 42,136.9
S$4116
  Bottom 0.152: 39.6,137.9 40.4,137.1
S$4117
  Bottom 0.152: 40.4,137.1 40.4,136.9
S$4118
  Bottom 0.152: 37.6,137.9 37.8,137.9
S$4119
  Bottom 0.152: 37.8,137.9 38.8,136.9
S$4120
  Bottom 0.152: 35.6,137.9 36.2,137.9
S$4121
  Bottom 0.152: 36.2,137.9 37.2,136.9
S$4122
  Bottom 0.152: 33.6,137.9 34.6,136.9
S$4123
  Bottom 0.152: 34.6,136.9 35.6,136.9
S$4124
  Bottom 0.152: 52.6,133.9 51.6,132.9
S$4125
  Bottom 0.152: 51.6,132.9 50.8,132.9
S$4126
  Bottom 0.152: 50.6,133.9 49.6,132.9
S$4127
  Bottom 0.152: 49.6,132.9 49.2,132.9
S$4128
  Bottom 0.152: 48.6,133.9 47.6,132.9
S$4129
  Bottom 0.152: 46.6,133.9 46,133.3
S$4130
  Bottom 0.152: 46,133.3 46,132.9
S$4131
  Bottom 0.152: 44.6,133.9 44.4,133.7
S$4132
  Bottom 0.152: 44.4,133.7 44.4,132.9
S$4133
  Bottom 0.152: 42.6,133.9 42.8,133.7
S$4134
  Bottom 0.152: 42.8,133.7 42.8,132.9
S$4135
  Bottom 0.152: 40.6,133.9 41.2,133.3
S$4136
  Bottom 0.152: 41.2,133.3 41.2,132.9
S$4137
  Bottom 0.152: 38.6,133.9 39.6,132.9
S$4138
  Bottom 0.152: 36.6,133.9 37.6,132.9
S$4139
  Bottom 0.152: 37.6,132.9 38,132.9
S$4140
  Bottom 0.152: 34.6,133.9 35.6,132.9
S$4141
  Bottom 0.152: 35.6,132.9 36.4,132.9
S$4142
  Bottom 0.152: 37.4,127.9 36.4,128.9
S$4143
  Bottom 0.152: 36.4,128.9 34.8,128.9
S$4144
  Bottom 0.152: 35.4,127.9 34.6,127.9
S$4145
  Bottom 0.152: 34.6,127.9 33.6,128.9
S$4146
  Bottom 0.152: 33.6,128.9 33.2,128.9
S$4147
  Bottom 0.152: 33.4,127.9 32.6,127.9
S$4148
  Bottom 0.152: 32.6,127.9 31.6,128.9
S$4149
  Bottom 0.152: 31.4,127.9 31,127.9
S$4150
  Bottom 0.152: 31,127.9 30,128.9
S$4151
  Bottom 0.152: 29.4,127.9 28.4,128.9
S$4152
  Bottom 0.152: 27.4,127.9 26.8,128.5
S$4153
  Bottom 0.152: 26.8,128.5 26.8,128.9
S$4154
  Bottom 0.152: 36.4,131.9 35.8,131.9
S$4155
  Bottom 0.152: 35.8,131.9 34.8,132.9
S$4156
  Bottom 0.152: 34.8,132.9 34,132.9
S$4157
  Bottom 0.152: 34.4,131.9 33.8,131.9
S$4158
  Bottom 0.152: 33.8,131.9 32.8,132.9
S$4159
  Bottom 0.152: 32.8,132.9 32.4,132.9
S$4160
  Bottom 0.152: 32.4,131.9 31.8,131.9
S$4161
  Bottom 0.152: 31.8,131.9 30.8,132.9
S$4162
  Bottom 0.152: 30.4,131.9 30.2,131.9
S$4163
  Bottom 0.152: 30.2,131.9 29.2,132.9
S$4164
  Bottom 0.152: 28.4,131.9 27.6,132.7
S$4165
  Bottom 0.152: 27.6,132.7 27.6,132.9
S$4166
  Bottom 0.152: 52.4,131.9 53,131.9
S$4167
  Bottom 0.152: 53,131.9 54,132.9
S$4168
  Bottom 0.152: 54.4,131.9 54.6,131.9
S$4169
  Bottom 0.152: 54.6,131.9 55.6,132.9
S$4170
  Bottom 0.152: 56.4,131.9 57.2,132.7
S$4171
  Bottom 0.152: 57.2,132.7 57.2,132.9
S$4172
  Bottom 0.152: 58.4,131.9 58.8,132.3
S$4173
  Bottom 0.152: 58.8,132.3 58.8,132.9
S$4174
  Bottom 0.152: 60.4,131.9 60.4,132.9
S$4175
  Bottom 0.152: 50.4,131.9 51.4,131.9
S$4176
  Bottom 0.152: 51.4,131.9 52.4,132.9
S$4177
  Bottom 0.152: 51.4,127.9 52.4,128.9
S$4178
  Bottom 0.152: 52.4,128.9 53.2,128.9
S$4179
  Bottom 0.152: 53.4,127.9 53.8,127.9
S$4180
  Bottom 0.152: 53.8,127.9 54.8,128.9
S$4181
  Bottom 0.152: 55.4,127.9 56.4,128.9
S$4182
  Bottom 0.152: 57.4,127.9 58,128.5
S$4183
  Bottom 0.152: 58,128.5 58,128.9
S$4184
  Bottom 0.152: 59.4,127.9 59.6,128.1
S$4185
  Bottom 0.152: 59.6,128.1 59.6,128.9
S$4186
  Bottom 0.152: 61.4,127.9 61.2,128.1
S$4187
  Bottom 0.152: 61.2,128.1 61.2,128.9
S$4188
  Bottom 0.152: 63.4,127.9 62.8,128.5
S$4189
  Bottom 0.152: 62.8,128.5 62.8,128.9
S$4190
  Bottom 0.152: 65.4,127.9 64.4,128.9
S$4191
  Bottom 0.152: 67.4,127.9 67,127.9
S$4192
  Bottom 0.152: 67,127.9 66,128.9
S$4193
  Bottom 0.152: 69.4,127.9 68.6,127.9
S$4194
  Bottom 0.152: 68.6,127.9 67.6,128.9
S$4195
  Bottom 0.152: 62.4,131.9 62,132.3
S$4196
  Bottom 0.152: 62,132.3 62,132.9
S$4197
  Bottom 0.152: 64.4,131.9 63.6,132.7
S$4198
  Bottom 0.152: 63.6,132.7 63.6,132.9
S$4199
  Bottom 0.152: 66.4,131.9 66.2,131.9
S$4200
  Bottom 0.152: 66.2,131.9 65.2,132.9
S$4201
  Bottom 0.152: 68.4,131.9 67.8,131.9
S$4202
  Bottom 0.152: 67.8,131.9 66.8,132.9
S$4203
  Bottom 0.152: 70.4,129.9 69.4,128.9
S$4204
  Bottom 0.152: 69.4,128.9 68.4,128.9
S$4205
  Bottom 0.152: 68.6,133.9 69.2,133.9
S$4206
  Bottom 0.152: 69.2,133.9 70.2,132.9
S$4207
  Bottom 0.152: 70.2,132.9 70.8,132.9
S$4208
  Bottom 0.152: 70.6,133.9 71.6,132.9
S$4209
  Bottom 0.152: 71.6,132.9 72.4,132.9
S$4210
  Bottom 0.152: 72.6,133.9 73.6,132.9
S$4211
  Bottom 0.152: 73.6,132.9 74,132.9
S$4212
  Bottom 0.152: 74.6,133.9 75.6,132.9
S$4213
  Bottom 0.152: 76.6,133.9 77.2,133.3
S$4214
  Bottom 0.152: 77.2,133.3 77.2,132.9
S$4215
  Bottom 0.152: 67.6,137.9 68.6,136.9
S$4216
  Bottom 0.152: 68.6,136.9 70,136.9
S$4217
  Bottom 0.152: 69.6,137.9 70,137.9
S$4218
  Bottom 0.152: 70,137.9 71,136.9
S$4219
  Bottom 0.152: 71,136.9 71.6,136.9
S$4220
  Bottom 0.152: 71.6,137.9 72.2,137.9
S$4221
  Bottom 0.152: 72.2,137.9 73.2,136.9
S$4222
  Bottom 0.152: 73.6,137.9 73.8,137.9
S$4223
  Bottom 0.152: 73.8,137.9 74.8,136.9
S$4224
  Bottom 0.152: 75.6,137.9 76.4,137.1
S$4225
  Bottom 0.152: 76.4,137.1 76.4,136.9
S$4226
  Bottom 0.152: 69.2,132.9 68,132.9
S$4227
  Bottom 0.152: 68,132.9 67,133.9
S$4228
  Bottom 0.152: 67,133.9 66.6,133.9
S$4229
  Bottom 0.152: 102.8,131.9 102.2,131.9
S$4230
  Bottom 0.152: 102.2,131.9 101.2,132.9
S$4231
  Bottom 0.152: 100.8,131.9 100.6,131.9
S$4232
  Bottom 0.152: 100.6,131.9 99.6,132.9
S$4233
  Bottom 0.152: 98.8,131.9 98,132.7
S$4234
  Bottom 0.152: 98,132.7 98,132.9
S$4235
  Bottom 0.152: 96.8,131.9 96.4,132.3
S$4236
  Bottom 0.152: 96.4,132.3 96.4,132.9
S$4237
  Bottom 0.152: 94.8,131.9 94.8,132.9
S$4238
  Bottom 0.152: 104.8,131.9 103.8,131.9
S$4239
  Bottom 0.152: 103.8,131.9 102.8,132.9
S$4240
  Bottom 0.152: 103.8,127.9 102.8,128.9
S$4241
  Bottom 0.152: 102.8,128.9 102,128.9
S$4242
  Bottom 0.152: 101.8,127.9 101.4,127.9
S$4243
  Bottom 0.152: 101.4,127.9 100.4,128.9
S$4244
  Bottom 0.152: 99.8,127.9 98.8,128.9
S$4245
  Bottom 0.152: 97.8,127.9 97.2,128.5
S$4246
  Bottom 0.152: 97.2,128.5 97.2,128.9
S$4247
  Bottom 0.152: 95.8,127.9 95.6,128.1
S$4248
  Bottom 0.152: 95.6,128.1 95.6,128.9
S$4249
  Bottom 0.152: 93.8,127.9 94,128.1
S$4250
  Bottom 0.152: 94,128.1 94,128.9
S$4251
  Bottom 0.152: 91.8,127.9 92.4,128.5
S$4252
  Bottom 0.152: 92.4,128.5 92.4,128.9
S$4253
  Bottom 0.152: 89.8,127.9 90.8,128.9
S$4254
  Bottom 0.152: 87.8,127.9 88.2,127.9
S$4255
  Bottom 0.152: 88.2,127.9 89.2,128.9
S$4256
  Bottom 0.152: 85.8,127.9 86.6,127.9
S$4257
  Bottom 0.152: 86.6,127.9 87.6,128.9
S$4258
  Bottom 0.152: 92.8,131.9 93.2,132.3
S$4259
  Bottom 0.152: 93.2,132.3 93.2,132.9
S$4260
  Bottom 0.152: 90.8,131.9 91.6,132.7
S$4261
  Bottom 0.152: 91.6,132.7 91.6,132.9
S$4262
  Bottom 0.152: 88.8,131.9 89,131.9
S$4263
  Bottom 0.152: 89,131.9 90,132.9
S$4264
  Bottom 0.152: 86.8,131.9 87.4,131.9
S$4265
  Bottom 0.152: 87.4,131.9 88.4,132.9
S$4266
  Bottom 0.152: 84.8,129.9 85.8,128.9
S$4267
  Bottom 0.152: 85.8,128.9 86.8,128.9
S$4268
  Bottom 0.152: 86.6,133.9 86,133.9
S$4269
  Bottom 0.152: 86,133.9 85,132.9
S$4270
  Bottom 0.152: 85,132.9 84.4,132.9
S$4271
  Bottom 0.152: 84.6,133.9 83.6,132.9
S$4272
  Bottom 0.152: 83.6,132.9 82.8,132.9
S$4273
  Bottom 0.152: 82.6,133.9 81.6,132.9
S$4274
  Bottom 0.152: 81.6,132.9 81.2,132.9
S$4275
  Bottom 0.152: 80.6,133.9 79.6,132.9
S$4276
  Bottom 0.152: 78.6,133.9 78,133.3
S$4277
  Bottom 0.152: 78,133.3 78,132.9
S$4278
  Bottom 0.152: 87.6,137.9 86.6,136.9
S$4279
  Bottom 0.152: 86.6,136.9 85.2,136.9
S$4280
  Bottom 0.152: 85.6,137.9 85.2,137.9
S$4281
  Bottom 0.152: 85.2,137.9 84.2,136.9
S$4282
  Bottom 0.152: 84.2,136.9 83.6,136.9
S$4283
  Bottom 0.152: 83.6,137.9 83,137.9
S$4284
  Bottom 0.152: 83,137.9 82,136.9
S$4285
  Bottom 0.152: 81.6,137.9 81.4,137.9
S$4286
  Bottom 0.152: 81.4,137.9 80.4,136.9
S$4287
  Bottom 0.152: 79.6,137.9 78.8,137.1
S$4288
  Bottom 0.152: 78.8,137.1 78.8,136.9
S$4289
  Bottom 0.152: 86,132.9 87.2,132.9
S$4290
  Bottom 0.152: 87.2,132.9 88.2,133.9
S$4291
  Bottom 0.152: 88.2,133.9 88.6,133.9
S$4292  (2 unrouted)
  Top 0.508: 117,137.4 117,132.9 | 117,132.9 117,128.4 | 117,132.9 146,132.9 146,134.9
  Top 1.8: 118,134.4 116,134.4 | 118,137.4 117,137.4 116,137.4 | 118,131.4 116,131.4 | 118,128.4 117,128.4 116,128.4
S$4293
  Top 1.778: -52.08,129.72 -52.08,131.25
S$4294
  Top 1.778: -52.08,134.55 -52.08,136.08
S$4295
  Top 1.778: -47,129.72 -47,131.25
S$4296
  Top 1.778: -47,134.55 -47,136.08
S$4297
  Top 1.778: -41.92,129.72 -41.92,131.25
S$4298
  Top 1.778: -41.92,134.55 -41.92,136.08
S$4299
  Top 1.778: 145.92,129.72 145.92,131.25
S$4300
  Top 1.778: 145.92,134.55 145.92,136.08
S$4301
  Top 1.778: 151,129.72 151,131.25
S$4302
  Top 1.778: 151,134.55 151,136.08
S$4303
  Top 1.778: 156.08,129.72 156.08,131.25
S$4304
  Top 1.778: 156.08,134.55 156.08,136.08
S$4305  (via drill 0.2)
  other vias: 26.4,139.3
S$4306  (via drill 0.2)
  other vias: 43.4,126.5
S$4307  (via drill 0.2)
  other vias: 60.6,139.3
S$4308  (via drill 0.2)
  other vias: 77.6,126.5
S$4309  (via drill 0.2)
  other vias: 93.6,139.3
S$4310  (via drill 0.2)
  other vias: 104.8,139.3
S$4311  (via drill 0.2)
  other vias: 10.4,126.5
S$4312  (via drill 0.2)
  other vias: -0.8,126.5
S$4313
  Bottom 0.8: 61.4,145.8 61.4,144
S$4314
  Bottom 0.8: 63.4,145.8 63.4,144
S$4315
  Bottom 0.8: 60.4,148 60.4,149.8
S$4316
  Bottom 0.8: 62.4,148 62.4,149.8
S$4317
  Bottom 0.8: 57.4,145.8 57.4,144
S$4318
  Bottom 0.8: 59.4,145.8 59.4,144
S$4319
  Bottom 0.8: 58.4,148 58.4,149.8
S$4320
  Bottom 0.8: 56.4,148 56.4,149.8
S$4321
  Bottom 0.8: 55.4,145.8 55.4,144
S$4322
  Bottom 0.8: 53.4,145.8 53.4,144
S$4323
  Bottom 0.8: 54.4,148 54.4,149.8
S$4324
  Bottom 0.8: 52.4,148 52.4,149.8
S$4325
  Bottom 0.8: 51.4,145.8 51.4,144
S$4326
  Bottom 0.8: 49.4,145.8 49.4,144
S$4327
  Bottom 0.8: 50.4,148 50.4,149.8
S$4328
  Bottom 0.8: 69.4,145.8 69.4,144
S$4329
  Bottom 0.8: 71.4,145.8 71.4,144
S$4330
  Bottom 0.8: 68.4,148 68.4,149.8
S$4331
  Bottom 0.8: 70.4,148 70.4,149.8
S$4332
  Bottom 0.8: 65.4,145.8 65.4,144
S$4333
  Bottom 0.8: 67.4,145.8 67.4,144
S$4334
  Bottom 0.8: 64.4,148 64.4,149.8
S$4335
  Bottom 0.8: 66.4,148 66.4,149.8
S$4336
  Bottom 0.8: 44.6,153.8 44.6,152
S$4337
  Bottom 0.8: 46.6,153.8 46.6,152
S$4338
  Bottom 0.8: 43.6,156 43.6,157.8
S$4339
  Bottom 0.8: 45.6,156 45.6,157.8
S$4340
  Bottom 0.8: 40.6,153.8 40.6,152
S$4341
  Bottom 0.8: 42.6,153.8 42.6,152
S$4342
  Bottom 0.8: 41.6,156 41.6,157.8
S$4343
  Bottom 0.8: 39.6,156 39.6,157.8
S$4344
  Bottom 0.8: 38.6,153.8 38.6,152
S$4345
  Bottom 0.8: 36.6,153.8 36.6,152
S$4346
  Bottom 0.8: 37.6,156 37.6,157.8
S$4347
  Bottom 0.8: 35.6,156 35.6,157.8
S$4348
  Bottom 0.8: 34.6,153.8 34.6,152
S$4349
  Bottom 0.8: 32.6,153.8 32.6,152
S$4350
  Bottom 0.8: 33.6,156 33.6,157.8
S$4351
  Bottom 0.8: 52.6,153.8 52.6,152
S$4352
  Bottom 0.8: 54.6,153.8 54.6,152
S$4353
  Bottom 0.8: 51.6,156 51.6,157.8
S$4354
  Bottom 0.8: 53.6,156 53.6,157.8
S$4355
  Bottom 0.8: 48.6,153.8 48.6,152
S$4356
  Bottom 0.8: 50.6,153.8 50.6,152
S$4357
  Bottom 0.8: 47.6,156 47.6,157.8
S$4358
  Bottom 0.8: 49.6,156 49.6,157.8
S$4359
  Bottom 0.8: 27.4,145.8 27.4,144
S$4360
  Bottom 0.8: 29.4,145.8 29.4,144
S$4361
  Bottom 0.8: 26.4,148 26.4,149.8
S$4362
  Bottom 0.8: 28.4,148 28.4,149.8
S$4363
  Bottom 0.8: 23.4,145.8 23.4,144
S$4364
  Bottom 0.8: 25.4,145.8 25.4,144
S$4365
  Bottom 0.8: 24.4,148 24.4,149.8
S$4366
  Bottom 0.8: 22.4,148 22.4,149.8
S$4367
  Bottom 0.8: 21.4,145.8 21.4,144
S$4368
  Bottom 0.8: 19.4,145.8 19.4,144
S$4369
  Bottom 0.8: 20.4,148 20.4,149.8
S$4370
  Bottom 0.8: 18.4,148 18.4,149.8
S$4371
  Bottom 0.8: 17.4,145.8 17.4,144
S$4372
  Bottom 0.8: 15.4,145.8 15.4,144
S$4373
  Bottom 0.8: 16.4,148 16.4,149.8
S$4374
  Bottom 0.8: 35.4,145.8 35.4,144
S$4375
  Bottom 0.8: 37.4,145.8 37.4,144
S$4376
  Bottom 0.8: 34.4,148 34.4,149.8
S$4377
  Bottom 0.8: 36.4,148 36.4,149.8
S$4378
  Bottom 0.8: 31.4,145.8 31.4,144
S$4379
  Bottom 0.8: 33.4,145.8 33.4,144
S$4380
  Bottom 0.8: 30.4,148 30.4,149.8
S$4381
  Bottom 0.8: 32.4,148 32.4,149.8
S$4382
  Bottom 0.8: 78.6,153.8 78.6,152
S$4383
  Bottom 0.8: 80.6,153.8 80.6,152
S$4384
  Bottom 0.8: 77.6,156 77.6,157.8
S$4385
  Bottom 0.8: 79.6,156 79.6,157.8
S$4386
  Bottom 0.8: 74.6,153.8 74.6,152
S$4387
  Bottom 0.8: 76.6,153.8 76.6,152
S$4388
  Bottom 0.8: 75.6,156 75.6,157.8
S$4389
  Bottom 0.8: 73.6,156 73.6,157.8
S$4390
  Bottom 0.8: 72.6,153.8 72.6,152
S$4391
  Bottom 0.8: 70.6,153.8 70.6,152
S$4392
  Bottom 0.8: 71.6,156 71.6,157.8
S$4393
  Bottom 0.8: 69.6,156 69.6,157.8
S$4394
  Bottom 0.8: 68.6,153.8 68.6,152
S$4395
  Bottom 0.8: 66.6,153.8 66.6,152
S$4396
  Bottom 0.8: 67.6,156 67.6,157.8
S$4397
  Bottom 0.8: 86.6,153.8 86.6,152
S$4398
  Bottom 0.8: 88.6,153.8 88.6,152
S$4399
  Bottom 0.8: 85.6,156 85.6,157.8
S$4400
  Bottom 0.8: 87.6,156 87.6,157.8
S$4401
  Bottom 0.8: 82.6,153.8 82.6,152
S$4402
  Bottom 0.8: 84.6,153.8 84.6,152
S$4403
  Bottom 0.8: 81.6,156 81.6,157.8
S$4404
  Bottom 0.8: 83.6,156 83.6,157.8
S$4405
  Bottom 0.8: 10.2,153.8 10.2,152
S$4406
  Bottom 0.8: 12.2,153.8 12.2,152
S$4407
  Bottom 0.8: 9.2,156 9.2,157.8
S$4408
  Bottom 0.8: 11.2,156 11.2,157.8
S$4409
  Bottom 0.8: 6.2,153.8 6.2,152
S$4410
  Bottom 0.8: 8.2,153.8 8.2,152
S$4411
  Bottom 0.8: 7.2,156 7.2,157.8
S$4412
  Bottom 0.8: 5.2,156 5.2,157.8
S$4413
  Bottom 0.8: 4.2,153.8 4.2,152
S$4414
  Bottom 0.8: 2.2,153.8 2.2,152
S$4415
  Bottom 0.8: 3.2,156 3.2,157.8
S$4416
  Bottom 0.8: 1.2,156 1.2,157.8
S$4417
  Bottom 0.8: 0.2,153.8 0.2,152
S$4418
  Bottom 0.8: -1.8,153.8 -1.8,152
S$4419
  Bottom 0.8: -0.8,156 -0.8,157.8
S$4420
  Bottom 0.8: 18.2,153.8 18.2,152
S$4421
  Bottom 0.8: 20.2,153.8 20.2,152
S$4422
  Bottom 0.8: 17.2,156 17.2,157.8
S$4423
  Bottom 0.8: 19.2,156 19.2,157.8
S$4424
  Bottom 0.8: 14.2,153.8 14.2,152
S$4425
  Bottom 0.8: 16.2,153.8 16.2,152
S$4426
  Bottom 0.8: 13.2,156 13.2,157.8
S$4427
  Bottom 0.8: 15.2,156 15.2,157.8
S$4428
  Bottom 0.8: 95.8,145.8 95.8,144
S$4429
  Bottom 0.8: 97.8,145.8 97.8,144
S$4430
  Bottom 0.8: 94.8,148 94.8,149.8
S$4431
  Bottom 0.8: 96.8,148 96.8,149.8
S$4432
  Bottom 0.8: 91.8,145.8 91.8,144
S$4433
  Bottom 0.8: 93.8,145.8 93.8,144
S$4434
  Bottom 0.8: 92.8,148 92.8,149.8
S$4435
  Bottom 0.8: 90.8,148 90.8,149.8
S$4436
  Bottom 0.8: 89.8,145.8 89.8,144
S$4437
  Bottom 0.8: 87.8,145.8 87.8,144
S$4438
  Bottom 0.8: 88.8,148 88.8,149.8
S$4439
  Bottom 0.8: 86.8,148 86.8,149.8
S$4440
  Bottom 0.8: 85.8,145.8 85.8,144
S$4441
  Bottom 0.8: 83.8,145.8 83.8,144
S$4442
  Bottom 0.8: 84.8,148 84.8,149.8
S$4443
  Bottom 0.8: 103.8,145.8 103.8,144
S$4444
  Bottom 0.8: 105.8,145.8 105.8,144
S$4445
  Bottom 0.8: 102.8,148 102.8,149.8
S$4446
  Bottom 0.8: 104.8,148 104.8,149.8
S$4447
  Bottom 0.8: 99.8,145.8 99.8,144
S$4448
  Bottom 0.8: 101.8,145.8 101.8,144
S$4449
  Bottom 0.8: 98.8,148 98.8,149.8
S$4450
  Bottom 0.8: 100.8,148 100.8,149.8
S$4451  (via drill 0.2)
  other vias: 1.2,154.9
S$4452  (via drill 0.2)
  other vias: 2.8,154.9
S$4453  (via drill 0.2)
  other vias: 4.4,154.9
S$4454  (via drill 0.2)
  other vias: 6,154.9
S$4455  (via drill 0.2)
  other vias: 7.6,154.9
S$4456  (via drill 0.2)
  other vias: 9.2,154.9
S$4457  (via drill 0.2)
  other vias: 10.8,154.9
S$4458  (via drill 0.2)
  other vias: 12.4,154.9
S$4459  (via drill 0.2)
  other vias: 14,154.9
S$4460  (via drill 0.2)
  other vias: 15.6,154.9
S$4461  (via drill 0.2)
  other vias: 17.2,154.9
S$4462  (via drill 0.2)
  other vias: 2,150.9
S$4463  (via drill 0.2)
  other vias: 3.6,150.9
S$4464  (via drill 0.2)
  other vias: 5.2,150.9
S$4465  (via drill 0.2)
  other vias: 6.8,150.9
S$4466  (via drill 0.2)
  other vias: 8.4,150.9
S$4467  (via drill 0.2)
  other vias: 10,150.9
S$4468  (via drill 0.2)
  other vias: 11.6,150.9
S$4469  (via drill 0.2)
  other vias: 13.2,150.9
S$4470  (via drill 0.2)
  other vias: 14.8,150.9
S$4471  (via drill 0.2)
  other vias: 16.4,150.9
S$4472  (via drill 0.2)
  other vias: 18,146.9
S$4473  (via drill 0.2)
  other vias: 19.6,146.9
S$4474  (via drill 0.2)
  other vias: 21.2,146.9
S$4475  (via drill 0.2)
  other vias: 22.8,146.9
S$4476  (via drill 0.2)
  other vias: 24.4,146.9
S$4477  (via drill 0.2)
  other vias: 18.8,150.9
S$4478  (via drill 0.2)
  other vias: 20.4,150.9
S$4479  (via drill 0.2)
  other vias: 22,150.9
S$4480  (via drill 0.2)
  other vias: 23.6,150.9
S$4481  (via drill 0.2)
  other vias: 25.2,150.9
S$4482  (via drill 0.2)
  other vias: 26,146.9
S$4483  (via drill 0.2)
  other vias: 51.6,154.9
S$4484  (via drill 0.2)
  other vias: 50,154.9
S$4485  (via drill 0.2)
  other vias: 48.4,154.9
S$4486  (via drill 0.2)
  other vias: 46.8,154.9
S$4487  (via drill 0.2)
  other vias: 45.2,154.9
S$4488  (via drill 0.2)
  other vias: 43.6,154.9
S$4489  (via drill 0.2)
  other vias: 42,154.9
S$4490  (via drill 0.2)
  other vias: 40.4,154.9
S$4491  (via drill 0.2)
  other vias: 38.8,154.9
S$4492  (via drill 0.2)
  other vias: 37.2,154.9
S$4493  (via drill 0.2)
  other vias: 35.6,154.9
S$4494  (via drill 0.2)
  other vias: 50.8,150.9
S$4495  (via drill 0.2)
  other vias: 49.2,150.9
S$4496  (via drill 0.2)
  other vias: 47.6,150.9
S$4497  (via drill 0.2)
  other vias: 46,150.9
S$4498  (via drill 0.2)
  other vias: 44.4,150.9
S$4499  (via drill 0.2)
  other vias: 42.8,150.9
S$4500  (via drill 0.2)
  other vias: 41.2,150.9
S$4501  (via drill 0.2)
  other vias: 39.6,150.9
S$4502  (via drill 0.2)
  other vias: 38,150.9
S$4503  (via drill 0.2)
  other vias: 36.4,150.9
S$4504  (via drill 0.2)
  other vias: 34.8,146.9
S$4505  (via drill 0.2)
  other vias: 33.2,146.9
S$4506  (via drill 0.2)
  other vias: 31.6,146.9
S$4507  (via drill 0.2)
  other vias: 30,146.9
S$4508  (via drill 0.2)
  other vias: 28.4,146.9
S$4509  (via drill 0.2)
  other vias: 34,150.9
S$4510  (via drill 0.2)
  other vias: 32.4,150.9
S$4511  (via drill 0.2)
  other vias: 30.8,150.9
S$4512  (via drill 0.2)
  other vias: 29.2,150.9
S$4513  (via drill 0.2)
  other vias: 27.6,150.9
S$4514  (via drill 0.2)
  other vias: 26.8,146.9
S$4515  (via drill 0.2)
  other vias: 52.4,150.9
S$4516  (via drill 0.2)
  other vias: 54,150.9
S$4517  (via drill 0.2)
  other vias: 55.6,150.9
S$4518  (via drill 0.2)
  other vias: 57.2,150.9
S$4519  (via drill 0.2)
  other vias: 58.8,150.9
S$4520  (via drill 0.2)
  other vias: 60.4,150.9
S$4521  (via drill 0.2)
  other vias: 62,150.9
S$4522  (via drill 0.2)
  other vias: 63.6,150.9
S$4523  (via drill 0.2)
  other vias: 65.2,150.9
S$4524  (via drill 0.2)
  other vias: 66.8,150.9
S$4525  (via drill 0.2)
  other vias: 68.4,146.9
S$4526  (via drill 0.2)
  other vias: 53.2,146.9
S$4527  (via drill 0.2)
  other vias: 54.8,146.9
S$4528  (via drill 0.2)
  other vias: 56.4,146.9
S$4529  (via drill 0.2)
  other vias: 58,146.9
S$4530  (via drill 0.2)
  other vias: 59.6,146.9
S$4531  (via drill 0.2)
  other vias: 61.2,146.9
S$4532  (via drill 0.2)
  other vias: 62.8,146.9
S$4533  (via drill 0.2)
  other vias: 64.4,146.9
S$4534  (via drill 0.2)
  other vias: 66,146.9
S$4535  (via drill 0.2)
  other vias: 67.6,146.9
S$4536  (via drill 0.2)
  other vias: 69.2,150.9
S$4537  (via drill 0.2)
  other vias: 70.8,150.9
S$4538  (via drill 0.2)
  other vias: 72.4,150.9
S$4539  (via drill 0.2)
  other vias: 70,154.9
S$4540  (via drill 0.2)
  other vias: 71.6,154.9
S$4541  (via drill 0.2)
  other vias: 73.2,154.9
S$4542  (via drill 0.2)
  other vias: 74,150.9
S$4543  (via drill 0.2)
  other vias: 74.8,154.9
S$4544  (via drill 0.2)
  other vias: 75.6,150.9
S$4545  (via drill 0.2)
  other vias: 76.4,154.9
S$4546  (via drill 0.2)
  other vias: 77.2,150.9
S$4547  (via drill 0.2)
  other vias: 102.8,150.9
S$4548  (via drill 0.2)
  other vias: 101.2,150.9
S$4549  (via drill 0.2)
  other vias: 99.6,150.9
S$4550  (via drill 0.2)
  other vias: 98,150.9
S$4551  (via drill 0.2)
  other vias: 96.4,150.9
S$4552  (via drill 0.2)
  other vias: 94.8,150.9
S$4553  (via drill 0.2)
  other vias: 93.2,150.9
S$4554  (via drill 0.2)
  other vias: 91.6,150.9
S$4555  (via drill 0.2)
  other vias: 90,150.9
S$4556  (via drill 0.2)
  other vias: 88.4,150.9
S$4557  (via drill 0.2)
  other vias: 86.8,146.9
S$4558  (via drill 0.2)
  other vias: 102,146.9
S$4559  (via drill 0.2)
  other vias: 100.4,146.9
S$4560  (via drill 0.2)
  other vias: 98.8,146.9
S$4561  (via drill 0.2)
  other vias: 97.2,146.9
S$4562  (via drill 0.2)
  other vias: 95.6,146.9
S$4563  (via drill 0.2)
  other vias: 94,146.9
S$4564  (via drill 0.2)
  other vias: 92.4,146.9
S$4565  (via drill 0.2)