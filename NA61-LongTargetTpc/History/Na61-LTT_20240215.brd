# EAGLE board Na61-LTT_20240215 (EAGLE 9.6.2), part 3 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$2372  (via drill 0.2) (continued)
  other vias: 4.4,68
S$2373  (via drill 0.2)
  other vias: 6,68
S$2374  (via drill 0.2)
  other vias: 7.6,68
S$2375  (via drill 0.2)
  other vias: 9.2,68
S$2376  (via drill 0.2)
  other vias: 10.8,68
S$2377  (via drill 0.2)
  other vias: 12.4,68
S$2378  (via drill 0.2)
  other vias: 14,68
S$2379  (via drill 0.2)
  other vias: 15.6,68
S$2380  (via drill 0.2)
  other vias: 17.2,72
S$2381  (via drill 0.2)
  other vias: 18.8,72
S$2382  (via drill 0.2)
  other vias: 20.4,72
S$2383  (via drill 0.2)
  other vias: 18,76
S$2384  (via drill 0.2)
  other vias: 19.6,76
S$2385  (via drill 0.2)
  other vias: 21.2,76
S$2386  (via drill 0.2)
  other vias: 22,72
S$2387  (via drill 0.2)
  other vias: 22.8,76
S$2388  (via drill 0.2)
  other vias: 23.6,72
S$2389  (via drill 0.2)
  other vias: 24.4,76
S$2390  (via drill 0.2)
  other vias: 25.2,72
S$2391  (via drill 0.2)
  other vias: 50.8,72
S$2392  (via drill 0.2)
  other vias: 49.2,72
S$2393  (via drill 0.2)
  other vias: 47.6,72
S$2394  (via drill 0.2)
  other vias: 46,72
S$2395  (via drill 0.2)
  other vias: 44.4,72
S$2396  (via drill 0.2)
  other vias: 42.8,72
S$2397  (via drill 0.2)
  other vias: 41.2,72
S$2398  (via drill 0.2)
  other vias: 39.6,72
S$2399  (via drill 0.2)
  other vias: 38,72
S$2400  (via drill 0.2)
  other vias: 36.4,72
S$2401  (via drill 0.2)
  other vias: 34.8,68
S$2402  (via drill 0.2)
  other vias: 50,68
S$2403  (via drill 0.2)
  other vias: 48.4,68
S$2404  (via drill 0.2)
  other vias: 46.8,68
S$2405  (via drill 0.2)
  other vias: 45.2,68
S$2406  (via drill 0.2)
  other vias: 43.6,68
S$2407  (via drill 0.2)
  other vias: 42,68
S$2408  (via drill 0.2)
  other vias: 40.4,68
S$2409  (via drill 0.2)
  other vias: 38.8,68
S$2410  (via drill 0.2)
  other vias: 37.2,68
S$2411  (via drill 0.2)
  other vias: 35.6,68
S$2412  (via drill 0.2)
  other vias: 34,72
S$2413  (via drill 0.2)
  other vias: 32.4,72
S$2414  (via drill 0.2)
  other vias: 30.8,72
S$2415  (via drill 0.2)
  other vias: 33.2,76
S$2416  (via drill 0.2)
  other vias: 31.6,76
S$2417  (via drill 0.2)
  other vias: 30,76
S$2418  (via drill 0.2)
  other vias: 29.2,72
S$2419  (via drill 0.2)
  other vias: 28.4,76
S$2420  (via drill 0.2)
  other vias: 27.6,72
S$2421  (via drill 0.2)
  other vias: 26.8,76
S$2422  (via drill 0.2)
  other vias: 26,72
S$2423
  Bottom 0.152: -52.8,77 -51.8,76
S$2424
  Bottom 0.152: -51.8,76 -50.8,76
S$2425
  Bottom 0.152: -50.8,77 -50.2,77
S$2426
  Bottom 0.152: -50.2,77 -49.2,76
S$2427
  Bottom 0.152: -48.8,77 -48.6,77
S$2428
  Bottom 0.152: -48.6,77 -47.6,76
S$2429
  Bottom 0.152: -46.8,77 -46,76.2
S$2430
  Bottom 0.152: -46,76.2 -46,76
S$2431
  Bottom 0.152: -44.8,77 -44.4,76.6
S$2432
  Bottom 0.152: -44.4,76.6 -44.4,76
S$2433
  Bottom 0.152: -42.8,77 -42.8,76
S$2434
  Bottom 0.152: -40.8,77 -41.2,76.6
S$2435
  Bottom 0.152: -41.2,76.6 -41.2,76
S$2436
  Bottom 0.152: -38.8,77 -39.6,76.2
S$2437
  Bottom 0.152: -39.6,76.2 -39.6,76
S$2438
  Bottom 0.152: -36.8,77 -37,77
S$2439
  Bottom 0.152: -37,77 -38,76
S$2440
  Bottom 0.152: -34.8,77 -35.4,77
S$2441
  Bottom 0.152: -35.4,77 -36.4,76
S$2442
  Bottom 0.152: -32.8,77 -33.8,76
S$2443
  Bottom 0.152: -33.8,76 -34.8,76
S$2444
  Bottom 0.152: -51.8,73 -50.8,72
S$2445
  Bottom 0.152: -50.8,72 -50,72
S$2446
  Bottom 0.152: -49.8,73 -48.8,72
S$2447
  Bottom 0.152: -48.8,72 -48.4,72
S$2448
  Bottom 0.152: -47.8,73 -46.8,72
S$2449
  Bottom 0.152: -45.8,73 -45.2,72.4
S$2450
  Bottom 0.152: -45.2,72.4 -45.2,72
S$2451
  Bottom 0.152: -43.8,73 -43.6,72.8
S$2452
  Bottom 0.152: -43.6,72.8 -43.6,72
S$2453
  Bottom 0.152: -41.8,73 -42,72.8
S$2454
  Bottom 0.152: -42,72.8 -42,72
S$2455
  Bottom 0.152: -39.8,73 -40.4,72.4
S$2456
  Bottom 0.152: -40.4,72.4 -40.4,72
S$2457
  Bottom 0.152: -37.8,73 -38.8,72
S$2458
  Bottom 0.152: -35.8,73 -36.8,72
S$2459
  Bottom 0.152: -36.8,72 -37.2,72
S$2460
  Bottom 0.152: -33.8,73 -34.8,72
S$2461
  Bottom 0.152: -34.8,72 -35.6,72
S$2462
  Bottom 0.152: -36.6,67 -35.6,68
S$2463
  Bottom 0.152: -35.6,68 -34,68
S$2464
  Bottom 0.152: -34.6,67 -33.8,67
S$2465
  Bottom 0.152: -33.8,67 -32.8,68
S$2466
  Bottom 0.152: -32.8,68 -32.4,68
S$2467
  Bottom 0.152: -32.6,67 -31.8,67
S$2468
  Bottom 0.152: -31.8,67 -30.8,68
S$2469
  Bottom 0.152: -30.6,67 -30.2,67
S$2470
  Bottom 0.152: -30.2,67 -29.2,68
S$2471
  Bottom 0.152: -28.6,67 -27.6,68
S$2472
  Bottom 0.152: -26.6,67 -26,67.6
S$2473
  Bottom 0.152: -26,67.6 -26,68
S$2474
  Bottom 0.152: -35.6,71 -35,71
S$2475
  Bottom 0.152: -35,71 -34,72
S$2476
  Bottom 0.152: -34,72 -33.2,72
S$2477
  Bottom 0.152: -33.6,71 -33,71
S$2478
  Bottom 0.152: -33,71 -32,72
S$2479
  Bottom 0.152: -32,72 -31.6,72
S$2480
  Bottom 0.152: -31.6,71 -31,71
S$2481
  Bottom 0.152: -31,71 -30,72
S$2482
  Bottom 0.152: -29.6,71 -29.4,71
S$2483
  Bottom 0.152: -29.4,71 -28.4,72
S$2484
  Bottom 0.152: -27.6,71 -26.8,71.8
S$2485
  Bottom 0.152: -26.8,71.8 -26.8,72
S$2486
  Bottom 0.152: 1.6,77 0.6,76
S$2487
  Bottom 0.152: 0.6,76 -0.4,76
S$2488
  Bottom 0.152: -0.4,77 -1,77
S$2489
  Bottom 0.152: -1,77 -2,76
S$2490
  Bottom 0.152: -2.4,77 -2.6,77
S$2491
  Bottom 0.152: -2.6,77 -3.6,76
S$2492
  Bottom 0.152: -4.4,77 -5.2,76.2
S$2493
  Bottom 0.152: -5.2,76.2 -5.2,76
S$2494
  Bottom 0.152: -6.4,77 -6.8,76.6
S$2495
  Bottom 0.152: -6.8,76.6 -6.8,76
S$2496
  Bottom 0.152: -8.4,77 -8.4,76
S$2497
  Bottom 0.152: -10.4,77 -10,76.6
S$2498
  Bottom 0.152: -10,76.6 -10,76
S$2499
  Bottom 0.152: -12.4,77 -11.6,76.2
S$2500
  Bottom 0.152: -11.6,76.2 -11.6,76
S$2501
  Bottom 0.152: -14.4,77 -14.2,77
S$2502
  Bottom 0.152: -14.2,77 -13.2,76
S$2503
  Bottom 0.152: -16.4,77 -15.8,77
S$2504
  Bottom 0.152: -15.8,77 -14.8,76
S$2505
  Bottom 0.152: -18.4,77 -17.4,76
S$2506
  Bottom 0.152: -17.4,76 -16.4,76
S$2507
  Bottom 0.152: 0.6,73 -0.4,72
S$2508
  Bottom 0.152: -0.4,72 -1.2,72
S$2509
  Bottom 0.152: -1.4,73 -2.4,72
S$2510
  Bottom 0.152: -2.4,72 -2.8,72
S$2511
  Bottom 0.152: -3.4,73 -4.4,72
S$2512
  Bottom 0.152: -5.4,73 -6,72.4
S$2513
  Bottom 0.152: -6,72.4 -6,72
S$2514
  Bottom 0.152: -7.4,73 -7.6,72.8
S$2515
  Bottom 0.152: -7.6,72.8 -7.6,72
S$2516
  Bottom 0.152: -9.4,73 -9.2,72.8
S$2517
  Bottom 0.152: -9.2,72.8 -9.2,72
S$2518
  Bottom 0.152: -11.4,73 -10.8,72.4
S$2519
  Bottom 0.152: -10.8,72.4 -10.8,72
S$2520
  Bottom 0.152: -13.4,73 -12.4,72
S$2521
  Bottom 0.152: -15.4,73 -14.4,72
S$2522
  Bottom 0.152: -14.4,72 -14,72
S$2523
  Bottom 0.152: -17.4,73 -16.4,72
S$2524
  Bottom 0.152: -16.4,72 -15.6,72
S$2525
  Bottom 0.152: -14.6,67 -15.6,68
S$2526
  Bottom 0.152: -15.6,68 -17.2,68
S$2527
  Bottom 0.152: -16.6,67 -17.4,67
S$2528
  Bottom 0.152: -17.4,67 -18.4,68
S$2529
  Bottom 0.152: -18.4,68 -18.8,68
S$2530
  Bottom 0.152: -18.6,67 -19.4,67
S$2531
  Bottom 0.152: -19.4,67 -20.4,68
S$2532
  Bottom 0.152: -20.6,67 -21,67
S$2533
  Bottom 0.152: -21,67 -22,68
S$2534
  Bottom 0.152: -22.6,67 -23.6,68
S$2535
  Bottom 0.152: -24.6,67 -25.2,67.6
S$2536
  Bottom 0.152: -25.2,67.6 -25.2,68
S$2537
  Bottom 0.152: -15.6,71 -16.2,71
S$2538
  Bottom 0.152: -16.2,71 -17.2,72
S$2539
  Bottom 0.152: -17.2,72 -18,72
S$2540
  Bottom 0.152: -17.6,71 -18.2,71
S$2541
  Bottom 0.152: -18.2,71 -19.2,72
S$2542
  Bottom 0.152: -19.2,72 -19.6,72
S$2543
  Bottom 0.152: -19.6,71 -20.2,71
S$2544
  Bottom 0.152: -20.2,71 -21.2,72
S$2545
  Bottom 0.152: -21.6,71 -21.8,71
S$2546
  Bottom 0.152: -21.8,71 -22.8,72
S$2547
  Bottom 0.152: -23.6,71 -24.4,71.8
S$2548
  Bottom 0.152: -24.4,71.8 -24.4,72
S$2549
  Bottom 0.152: 0.4,71 1,71
S$2550
  Bottom 0.152: 1,71 2,72
S$2551
  Bottom 0.152: 2.4,71 2.6,71
S$2552
  Bottom 0.152: 2.6,71 3.6,72
S$2553
  Bottom 0.152: 4.4,71 5.2,71.8
S$2554
  Bottom 0.152: 5.2,71.8 5.2,72
S$2555
  Bottom 0.152: 6.4,71 6.8,71.4
S$2556
  Bottom 0.152: 6.8,71.4 6.8,72
S$2557
  Bottom 0.152: 8.4,71 8.4,72
S$2558
  Bottom 0.152: -1.6,71 -0.6,71
S$2559
  Bottom 0.152: -0.6,71 0.4,72
S$2560
  Bottom 0.152: -0.6,67 0.4,68
S$2561
  Bottom 0.152: 0.4,68 1.2,68
S$2562
  Bottom 0.152: 1.4,67 1.8,67
S$2563
  Bottom 0.152: 1.8,67 2.8,68
S$2564
  Bottom 0.152: 3.4,67 4.4,68
S$2565
  Bottom 0.152: 5.4,67 6,67.6
S$2566
  Bottom 0.152: 6,67.6 6,68
S$2567
  Bottom 0.152: 7.4,67 7.6,67.2
S$2568
  Bottom 0.152: 7.6,67.2 7.6,68
S$2569
  Bottom 0.152: 9.4,67 9.2,67.2
S$2570
  Bottom 0.152: 9.2,67.2 9.2,68
S$2571
  Bottom 0.152: 11.4,67 10.8,67.6
S$2572
  Bottom 0.152: 10.8,67.6 10.8,68
S$2573
  Bottom 0.152: 13.4,67 12.4,68
S$2574
  Bottom 0.152: 15.4,67 15,67
S$2575
  Bottom 0.152: 15,67 14,68
S$2576
  Bottom 0.152: 17.4,67 16.6,67
S$2577
  Bottom 0.152: 16.6,67 15.6,68
S$2578
  Bottom 0.152: 10.4,71 10,71.4
S$2579
  Bottom 0.152: 10,71.4 10,72
S$2580
  Bottom 0.152: 12.4,71 11.6,71.8
S$2581
  Bottom 0.152: 11.6,71.8 11.6,72
S$2582
  Bottom 0.152: 14.4,71 14.2,71
S$2583
  Bottom 0.152: 14.2,71 13.2,72
S$2584
  Bottom 0.152: 16.4,71 15.8,71
S$2585
  Bottom 0.152: 15.8,71 14.8,72
S$2586
  Bottom 0.152: 18.4,69 17.4,68
S$2587
  Bottom 0.152: 17.4,68 16.4,68
S$2588
  Bottom 0.152: 16.6,73 17.2,73
S$2589
  Bottom 0.152: 17.2,73 18.2,72
S$2590
  Bottom 0.152: 18.2,72 18.8,72
S$2591
  Bottom 0.152: 18.6,73 19.6,72
S$2592
  Bottom 0.152: 19.6,72 20.4,72
S$2593
  Bottom 0.152: 20.6,73 21.6,72
S$2594
  Bottom 0.152: 21.6,72 22,72
S$2595
  Bottom 0.152: 22.6,73 23.6,72
S$2596
  Bottom 0.152: 24.6,73 25.2,72.4
S$2597
  Bottom 0.152: 25.2,72.4 25.2,72
S$2598
  Bottom 0.152: 15.6,77 16.6,76
S$2599
  Bottom 0.152: 16.6,76 18,76
S$2600
  Bottom 0.152: 17.6,77 18,77
S$2601
  Bottom 0.152: 18,77 19,76
S$2602
  Bottom 0.152: 19,76 19.6,76
S$2603
  Bottom 0.152: 19.6,77 20.2,77
S$2604
  Bottom 0.152: 20.2,77 21.2,76
S$2605
  Bottom 0.152: 21.6,77 21.8,77
S$2606
  Bottom 0.152: 21.8,77 22.8,76
S$2607
  Bottom 0.152: 23.6,77 24.4,76.2
S$2608
  Bottom 0.152: 24.4,76.2 24.4,76
S$2609
  Bottom 0.152: 17.2,72 16,72
S$2610
  Bottom 0.152: 16,72 15,73
S$2611
  Bottom 0.152: 15,73 14.6,73
S$2612
  Bottom 0.152: 50.8,71 50.2,71
S$2613
  Bottom 0.152: 50.2,71 49.2,72
S$2614
  Bottom 0.152: 48.8,71 48.6,71
S$2615
  Bottom 0.152: 48.6,71 47.6,72
S$2616
  Bottom 0.152: 46.8,71 46,71.8
S$2617
  Bottom 0.152: 46,71.8 46,72
S$2618
  Bottom 0.152: 44.8,71 44.4,71.4
S$2619
  Bottom 0.152: 44.4,71.4 44.4,72
S$2620
  Bottom 0.152: 42.8,71 42.8,72
S$2621
  Bottom 0.152: 52.8,71 51.8,71
S$2622
  Bottom 0.152: 51.8,71 50.8,72
S$2623
  Bottom 0.152: 51.8,67 50.8,68
S$2624
  Bottom 0.152: 50.8,68 50,68
S$2625
  Bottom 0.152: 49.8,67 49.4,67
S$2626
  Bottom 0.152: 49.4,67 48.4,68
S$2627
  Bottom 0.152: 47.8,67 46.8,68
S$2628
  Bottom 0.152: 45.8,67 45.2,67.6
S$2629
  Bottom 0.152: 45.2,67.6 45.2,68
S$2630
  Bottom 0.152: 43.8,67 43.6,67.2
S$2631
  Bottom 0.152: 43.6,67.2 43.6,68
S$2632
  Bottom 0.152: 41.8,67 42,67.2
S$2633
  Bottom 0.152: 42,67.2 42,68
S$2634
  Bottom 0.152: 39.8,67 40.4,67.6
S$2635
  Bottom 0.152: 40.4,67.6 40.4,68
S$2636
  Bottom 0.152: 37.8,67 38.8,68
S$2637
  Bottom 0.152: 35.8,67 36.2,67
S$2638
  Bottom 0.152: 36.2,67 37.2,68
S$2639
  Bottom 0.152: 33.8,67 34.6,67
S$2640
  Bottom 0.152: 34.6,67 35.6,68
S$2641
  Bottom 0.152: 40.8,71 41.2,71.4
S$2642
  Bottom 0.152: 41.2,71.4 41.2,72
S$2643
  Bottom 0.152: 38.8,71 39.6,71.8
S$2644
  Bottom 0.152: 39.6,71.8 39.6,72
S$2645
  Bottom 0.152: 36.8,71 37,71
S$2646
  Bottom 0.152: 37,71 38,72
S$2647
  Bottom 0.152: 34.8,71 35.4,71
S$2648
  Bottom 0.152: 35.4,71 36.4,72
S$2649
  Bottom 0.152: 32.8,69 33.8,68
S$2650
  Bottom 0.152: 33.8,68 34.8,68
S$2651
  Bottom 0.152: 34.6,73 34,73
S$2652
  Bottom 0.152: 34,73 33,72
S$2653
  Bottom 0.152: 33,72 32.4,72
S$2654
  Bottom 0.152: 32.6,73 31.6,72
S$2655
  Bottom 0.152: 31.6,72 30.8,72
S$2656
  Bottom 0.152: 30.6,73 29.6,72
S$2657
  Bottom 0.152: 29.6,72 29.2,72
S$2658
  Bottom 0.152: 28.6,73 27.6,72
S$2659
  Bottom 0.152: 26.6,73 26,72.4
S$2660
  Bottom 0.152: 26,72.4 26,72
S$2661
  Bottom 0.152: 35.6,77 34.6,76
S$2662
  Bottom 0.152: 34.6,76 33.2,76
S$2663
  Bottom 0.152: 33.6,77 33.2,77
S$2664
  Bottom 0.152: 33.2,77 32.2,76
S$2665
  Bottom 0.152: 32.2,76 31.6,76
S$2666
  Bottom 0.152: 31.6,77 31,77
S$2667
  Bottom 0.152: 31,77 30,76
S$2668
  Bottom 0.152: 29.6,77 29.4,77
S$2669
  Bottom 0.152: 29.4,77 28.4,76
S$2670
  Bottom 0.152: 27.6,77 26.8,76.2
S$2671
  Bottom 0.152: 26.8,76.2 26.8,76
S$2672
  Bottom 0.152: 34,72 35.2,72
S$2673
  Bottom 0.152: 35.2,72 36.2,73
S$2674
  Bottom 0.152: 36.2,73 36.6,73
S$2675  (2 unrouted)
  Top 0.813: 65,76.5 65,67.5
  Top 1.8: 66,73.5 64,73.5 | 66,76.5 65,76.5 64,76.5 | 66,70.5 64,70.5 | 66,67.5 65,67.5 64,67.5
S$2676
  Top 1.778: -104.08,68.83 -104.08,70.35
S$2677
  Top 1.778: -104.08,73.65 -104.08,75.17
S$2678
  Top 1.778: -99,68.83 -99,70.35
S$2679
  Top 1.778: -99,73.65 -99,75.17
S$2680
  Top 1.778: -93.92,68.83 -93.92,70.35
S$2681
  Top 1.778: -93.92,73.65 -93.92,75.17
S$2682
  Top 1.778: 93.92,68.83 93.92,70.35
S$2683
  Top 1.778: 93.92,73.65 93.92,75.17
S$2684
  Top 1.778: 99,68.83 99,70.35
S$2685
  Top 1.778: 99,73.65 99,75.17
S$2686
  Top 1.778: 104.08,68.83 104.08,70.35
S$2687
  Top 1.778: 104.08,73.65 104.08,75.17
S$2688  (via drill 0.2)
  other vias: -25.6,78.4
S$2689  (via drill 0.2)
  other vias: -8.6,65.6
S$2690  (via drill 0.2)
  other vias: 8.6,78.4
S$2691  (via drill 0.2)
  other vias: 25.6,65.6
S$2692  (via drill 0.2)
  other vias: 41.6,78.4
S$2693  (via drill 0.2)
  other vias: 52.8,78.4
S$2694  (via drill 0.2)
  other vias: -41.6,65.6
S$2695  (via drill 0.2)
  other vias: -52.8,65.6
S$2696
  Bottom 0.8: 9.4,84.9 9.4,83.1
S$2697
  Bottom 0.8: 11.4,84.9 11.4,83.1
S$2698
  Bottom 0.8: 8.4,87.1 8.4,88.9
S$2699
  Bottom 0.8: 10.4,87.1 10.4,88.9
S$2700
  Bottom 0.8: 5.4,84.9 5.4,83.1
S$2701
  Bottom 0.8: 7.4,84.9 7.4,83.1
S$2702
  Bottom 0.8: 6.4,87.1 6.4,88.9
S$2703
  Bottom 0.8: 4.4,87.1 4.4,88.9
S$2704
  Bottom 0.8: 3.4,84.9 3.4,83.1
S$2705
  Bottom 0.8: 1.4,84.9 1.4,83.1
S$2706
  Bottom 0.8: 2.4,87.1 2.4,88.9
S$2707
  Bottom 0.8: 0.4,87.1 0.4,88.9
S$2708
  Bottom 0.8: -0.6,84.9 -0.6,83.1
S$2709
  Bottom 0.8: -2.6,84.9 -2.6,83.1
S$2710
  Bottom 0.8: -1.6,87.1 -1.6,88.9
S$2711
  Bottom 0.8: 17.4,84.9 17.4,83.1
S$2712
  Bottom 0.8: 19.4,84.9 19.4,83.1
S$2713
  Bottom 0.8: 16.4,87.1 16.4,88.9
S$2714
  Bottom 0.8: 18.4,87.1 18.4,88.9
S$2715
  Bottom 0.8: 13.4,84.9 13.4,83.1
S$2716
  Bottom 0.8: 15.4,84.9 15.4,83.1
S$2717
  Bottom 0.8: 12.4,87.1 12.4,88.9
S$2718
  Bottom 0.8: 14.4,87.1 14.4,88.9
S$2719
  Bottom 0.8: -7.4,92.9 -7.4,91.1
S$2720
  Bottom 0.8: -5.4,92.9 -5.4,91.1
S$2721
  Bottom 0.8: -8.4,95.1 -8.4,96.9
S$2722
  Bottom 0.8: -6.4,95.1 -6.4,96.9
S$2723
  Bottom 0.8: -11.4,92.9 -11.4,91.1
S$2724
  Bottom 0.8: -9.4,92.9 -9.4,91.1
S$2725
  Bottom 0.8: -10.4,95.1 -10.4,96.9
S$2726
  Bottom 0.8: -12.4,95.1 -12.4,96.9
S$2727
  Bottom 0.8: -13.4,92.9 -13.4,91.1
S$2728
  Bottom 0.8: -15.4,92.9 -15.4,91.1
S$2729
  Bottom 0.8: -14.4,95.1 -14.4,96.9
S$2730
  Bottom 0.8: -16.4,95.1 -16.4,96.9
S$2731
  Bottom 0.8: -17.4,92.9 -17.4,91.1
S$2732
  Bottom 0.8: -19.4,92.9 -19.4,91.1
S$2733
  Bottom 0.8: -18.4,95.1 -18.4,96.9
S$2734
  Bottom 0.8: 0.6,92.9 0.6,91.1
S$2735
  Bottom 0.8: 2.6,92.9 2.6,91.1
S$2736
  Bottom 0.8: -0.4,95.1 -0.4,96.9
S$2737
  Bottom 0.8: 1.6,95.1 1.6,96.9
S$2738
  Bottom 0.8: -3.4,92.9 -3.4,91.1
S$2739
  Bottom 0.8: -1.4,92.9 -1.4,91.1
S$2740
  Bottom 0.8: -4.4,95.1 -4.4,96.9
S$2741
  Bottom 0.8: -2.4,95.1 -2.4,96.9
S$2742
  Bottom 0.8: -24.6,84.9 -24.6,83.1
S$2743
  Bottom 0.8: -22.6,84.9 -22.6,83.1
S$2744
  Bottom 0.8: -25.6,87.1 -25.6,88.9
S$2745
  Bottom 0.8: -23.6,87.1 -23.6,88.9
S$2746
  Bottom 0.8: -28.6,84.9 -28.6,83.1
S$2747
  Bottom 0.8: -26.6,84.9 -26.6,83.1
S$2748
  Bottom 0.8: -27.6,87.1 -27.6,88.9
S$2749
  Bottom 0.8: -29.6,87.1 -29.6,88.9
S$2750
  Bottom 0.8: -30.6,84.9 -30.6,83.1
S$2751
  Bottom 0.8: -32.6,84.9 -32.6,83.1
S$2752
  Bottom 0.8: -31.6,87.1 -31.6,88.9
S$2753
  Bottom 0.8: -33.6,87.1 -33.6,88.9
S$2754
  Bottom 0.8: -34.6,84.9 -34.6,83.1
S$2755
  Bottom 0.8: -36.6,84.9 -36.6,83.1
S$2756
  Bottom 0.8: -35.6,87.1 -35.6,88.9
S$2757
  Bottom 0.8: -16.6,84.9 -16.6,83.1
S$2758
  Bottom 0.8: -14.6,84.9 -14.6,83.1
S$2759
  Bottom 0.8: -17.6,87.1 -17.6,88.9
S$2760
  Bottom 0.8: -15.6,87.1 -15.6,88.9
S$2761
  Bottom 0.8: -20.6,84.9 -20.6,83.1
S$2762
  Bottom 0.8: -18.6,84.9 -18.6,83.1
S$2763
  Bottom 0.8: -21.6,87.1 -21.6,88.9
S$2764
  Bottom 0.8: -19.6,87.1 -19.6,88.9
S$2765
  Bottom 0.8: 26.6,92.9 26.6,91.1
S$2766
  Bottom 0.8: 28.6,92.9 28.6,91.1
S$2767
  Bottom 0.8: 25.6,95.1 25.6,96.9
S$2768
  Bottom 0.8: 27.6,95.1 27.6,96.9
S$2769
  Bottom 0.8: 22.6,92.9 22.6,91.1
S$2770
  Bottom 0.8: 24.6,92.9 24.6,91.1
S$2771
  Bottom 0.8: 23.6,95.1 23.6,96.9
S$2772
  Bottom 0.8: 21.6,95.1 21.6,96.9
S$2773
  Bottom 0.8: 20.6,92.9 20.6,91.1
S$2774
  Bottom 0.8: 18.6,92.9 18.6,91.1
S$2775
  Bottom 0.8: 19.6,95.1 19.6,96.9
S$2776
  Bottom 0.8: 17.6,95.1 17.6,96.9
S$2777
  Bottom 0.8: 16.6,92.9 16.6,91.1
S$2778
  Bottom 0.8: 14.6,92.9 14.6,91.1
S$2779
  Bottom 0.8: 15.6,95.1 15.6,96.9
S$2780
  Bottom 0.8: 34.6,92.9 34.6,91.1
S$2781
  Bottom 0.8: 36.6,92.9 36.6,91.1
S$2782
  Bottom 0.8: 33.6,95.1 33.6,96.9
S$2783
  Bottom 0.8: 35.6,95.1 35.6,96.9
S$2784
  Bottom 0.8: 30.6,92.9 30.6,91.1
S$2785
  Bottom 0.8: 32.6,92.9 32.6,91.1
S$2786
  Bottom 0.8: 29.6,95.1 29.6,96.9
S$2787
  Bottom 0.8: 31.6,95.1 31.6,96.9
S$2788
  Bottom 0.8: -41.8,92.9 -41.8,91.1
S$2789
  Bottom 0.8: -39.8,92.9 -39.8,91.1
S$2790
  Bottom 0.8: -42.8,95.1 -42.8,96.9
S$2791
  Bottom 0.8: -40.8,95.1 -40.8,96.9
S$2792
  Bottom 0.8: -45.8,92.9 -45.8,91.1
S$2793
  Bottom 0.8: -43.8,92.9 -43.8,91.1
S$2794
  Bottom 0.8: -44.8,95.1 -44.8,96.9
S$2795
  Bottom 0.8: -46.8,95.1 -46.8,96.9
S$2796
  Bottom 0.8: -47.8,92.9 -47.8,91.1
S$2797
  Bottom 0.8: -49.8,92.9 -49.8,91.1
S$2798
  Bottom 0.8: -48.8,95.1 -48.8,96.9
S$2799
  Bottom 0.8: -50.8,95.1 -50.8,96.9
S$2800
  Bottom 0.8: -51.8,92.9 -51.8,91.1
S$2801
  Bottom 0.8: -53.8,92.9 -53.8,91.1
S$2802
  Bottom 0.8: -52.8,95.1 -52.8,96.9
S$2803
  Bottom 0.8: -33.8,92.9 -33.8,91.1
S$2804
  Bottom 0.8: -31.8,92.9 -31.8,91.1
S$2805
  Bottom 0.8: -34.8,95.1 -34.8,96.9
S$2806
  Bottom 0.8: -32.8,95.1 -32.8,96.9
S$2807
  Bottom 0.8: -37.8,92.9 -37.8,91.1
S$2808
  Bottom 0.8: -35.8,92.9 -35.8,91.1
S$2809
  Bottom 0.8: -38.8,95.1 -38.8,96.9
S$2810
  Bottom 0.8: -36.8,95.1 -36.8,96.9
S$2811
  Bottom 0.8: 43.8,84.9 43.8,83.1
S$2812
  Bottom 0.8: 45.8,84.9 45.8,83.1
S$2813
  Bottom 0.8: 42.8,87.1 42.8,88.9
S$2814
  Bottom 0.8: 44.8,87.1 44.8,88.9
S$2815
  Bottom 0.8: 39.8,84.9 39.8,83.1
S$2816
  Bottom 0.8: 41.8,84.9 41.8,83.1
S$2817
  Bottom 0.8: 40.8,87.1 40.8,88.9
S$2818
  Bottom 0.8: 38.8,87.1 38.8,88.9
S$2819
  Bottom 0.8: 37.8,84.9 37.8,83.1
S$2820
  Bottom 0.8: 35.8,84.9 35.8,83.1
S$2821
  Bottom 0.8: 36.8,87.1 36.8,88.9
S$2822
  Bottom 0.8: 34.8,87.1 34.8,88.9
S$2823
  Bottom 0.8: 33.8,84.9 33.8,83.1
S$2824
  Bottom 0.8: 31.8,84.9 31.8,83.1
S$2825
  Bottom 0.8: 32.8,87.1 32.8,88.9
S$2826
  Bottom 0.8: 51.8,84.9 51.8,83.1
S$2827
  Bottom 0.8: 53.8,84.9 53.8,83.1
S$2828
  Bottom 0.8: 50.8,87.1 50.8,88.9
S$2829
  Bottom 0.8: 52.8,87.1 52.8,88.9
S$2830
  Bottom 0.8: 47.8,84.9 47.8,83.1
S$2831
  Bottom 0.8: 49.8,84.9 49.8,83.1
S$2832
  Bottom 0.8: 46.8,87.1 46.8,88.9
S$2833
  Bottom 0.8: 48.8,87.1 48.8,88.9
S$2834  (via drill 0.2)
  other vias: -50.8,94
S$2835  (via drill 0.2)
  other vias: -49.2,94
S$2836  (via drill 0.2)
  other vias: -47.6,94
S$2837  (via drill 0.2)
  other vias: -46,94
S$2838  (via drill 0.2)
  other vias: -44.4,94
S$2839  (via drill 0.2)
  other vias: -42.8,94
S$2840  (via drill 0.2)
  other vias: -41.2,94
S$2841  (via drill 0.2)
  other vias: -39.6,94
S$2842  (via drill 0.2)
  other vias: -38,94
S$2843  (via drill 0.2)
  other vias: -36.4,94
S$2844  (via drill 0.2)
  other vias: -34.8,94
S$2845  (via drill 0.2)
  other vias: -50,90
S$2846  (via drill 0.2)
  other vias: -48.4,90
S$2847  (via drill 0.2)
  other vias: -46.8,90
S$2848  (via drill 0.2)
  other vias: -45.2,90
S$2849  (via drill 0.2)
  other vias: -43.6,90
S$2850  (via drill 0.2)
  other vias: -42,90
S$2851  (via drill 0.2)
  other vias: -40.4,90
S$2852  (via drill 0.2)
  other vias: -38.8,90
S$2853  (via drill 0.2)
  other vias: -37.2,90
S$2854  (via drill 0.2)
  other vias: -35.6,90
S$2855  (via drill 0.2)
  other vias: -34,86
S$2856  (via drill 0.2)
  other vias: -32.4,86
S$2857  (via drill 0.2)
  other vias: -30.8,86
S$2858  (via drill 0.2)
  other vias: -29.2,86
S$2859  (via drill 0.2)
  other vias: -27.6,86
S$2860  (via drill 0.2)
  other vias: -33.2,90
S$2861  (via drill 0.2)
  other vias: -31.6,90
S$2862  (via drill 0.2)
  other vias: -30,90
S$2863  (via drill 0.2)
  other vias: -28.4,90
S$2864  (via drill 0.2)
  other vias: -26.8,90
S$2865  (via drill 0.2)
  other vias: -26,86
S$2866  (via drill 0.2)
  other vias: -0.4,94
S$2867  (via drill 0.2)
  other vias: -2,94
S$2868  (via drill 0.2)
  other vias: -3.6,94
S$2869  (via drill 0.2)
  other vias: -5.2,94
S$2870  (via drill 0.2)
  other vias: -6.8,94
S$2871  (via drill 0.2)
  other vias: -8.4,94
S$2872  (via drill 0.2)
  other vias: -10,94
S$2873  (via drill 0.2)
  other vias: -11.6,94
S$2874  (via drill 0.2)
  other vias: -13.2,94
S$2875  (via drill 0.2)
  other vias: -14.8,94
S$2876  (via drill 0.2)
  other vias: -16.4,94
S$2877  (via drill 0.2)
  other vias: -1.2,90
S$2878  (via drill 0.2)
  other vias: -2.8,90
S$2879  (via drill 0.2)
  other vias: -4.4,90
S$2880  (via drill 0.2)
  other vias: -6,90
S$2881  (via drill 0.2)
  other vias: -7.6,90
S$2882  (via drill 0.2)
  other vias: -9.2,90
S$2883  (via drill 0.2)
  other vias: -10.8,90
S$2884  (via drill 0.2)
  other vias: -12.4,90
S$2885  (via drill 0.2)
  other vias: -14,90
S$2886  (via drill 0.2)
  other vias: -15.6,90
S$2887  (via drill 0.2)
  other vias: -17.2,86
S$2888  (via drill 0.2)
  other vias: -18.8,86
S$2889  (via drill 0.2)
  other vias: -20.4,86
S$2890  (via drill 0.2)
  other vias: -22,86
S$2891  (via drill 0.2)
  other vias: -23.6,86
S$2892  (via drill 0.2)
  other vias: -18,90
S$2893  (via drill 0.2)
  other vias: -19.6,90
S$2894  (via drill 0.2)
  other vias: -21.2,90
S$2895  (via drill 0.2)
  other vias: -22.8,90
S$2896  (via drill 0.2)
  other vias: -24.4,90
S$2897  (via drill 0.2)
  other vias: -25.2,86
S$2898  (via drill 0.2)
  other vias: 0.4,90
S$2899  (via drill 0.2)
  other vias: 2,90
S$2900  (via drill 0.2)
  other vias: 3.6,90
S$2901  (via drill 0.2)
  other vias: 5.2,90
S$2902  (via drill 0.2)
  other vias: 6.8,90
S$2903  (via drill 0.2)
  other vias: 8.4,90
S$2904  (via drill 0.2)
  other vias: 10,90
S$2905  (via drill 0.2)
  other vias: 11.6,90
S$2906  (via drill 0.2)
  other vias: 13.2,90
S$2907  (via drill 0.2)
  other vias: 14.8,90
S$2908  (via drill 0.2)
  other vias: 16.4,86
S$2909  (via drill 0.2)
  other vias: 1.2,86
S$2910  (via drill 0.2)
  other vias: 2.8,86
S$2911  (via drill 0.2)
  other vias: 4.4,86
S$2912  (via drill 0.2)
  other vias: 6,86
S$2913  (via drill 0.2)
  other vias: 7.6,86
S$2914  (via drill 0.2)
  other vias: 9.2,86
S$2915  (via drill 0.2)
  other vias: 10.8,86
S$2916  (via drill 0.2)
  other vias: 12.4,86
S$2917  (via drill 0.2)
  other vias: 14,86
S$2918  (via drill 0.2)
  other vias: 15.6,86
S$2919  (via drill 0.2)
  other vias: 17.2,90
S$2920  (via drill 0.2)
  other vias: 18.8,90
S$2921  (via drill 0.2)
  other vias: 20.4,90
S$2922  (via drill 0.2)
  other vias: 18,94
S$2923  (via drill 0.2)
  other vias: 19.6,94
S$2924  (via drill 0.2)
  other vias: 21.2,94
S$2925  (via drill 0.2)
  other vias: 22,90
S$2926  (via drill 0.2)
  other vias: 22.8,94
S$2927  (via drill 0.2)
  other vias: 23.6,90
S$2928  (via drill 0.2)
  other vias: 24.4,94
S$2929  (via drill 0.2)
  other vias: 25.2,90
S$2930  (via drill 0.2)
  other vias: 50.8,90
S$2931  (via drill 0.2)
  other vias: 49.2,90
S$2932  (via drill 0.2)
  other vias: 47.6,90
S$2933  (via drill 0.2)
  other vias: 46,90
S$2934  (via drill 0.2)
  other vias: 44.4,90
S$2935  (via drill 0.2)
  other vias: 42.8,90
S$2936  (via drill 0.2)
  other vias: 41.2,90
S$2937  (via drill 0.2)
  other vias: 39.6,90
S$2938  (via drill 0.2)
  other vias: 38,90
S$2939  (via drill 0.2)
  other vias: 36.4,90
S$2940  (via drill 0.2)
  other vias: 34.8,86
S$2941  (via drill 0.2)
  other vias: 50,86
S$2942  (via drill 0.2)
  other vias: 48.4,86
S$2943  (via drill 0.2)
  other vias: 46.8,86
S$2944  (via drill 0.2)
  other vias: 45.2,86
S$2945  (via drill 0.2)
  other vias: 43.6,86
S$2946  (via drill 0.2)
  other vias: 42,86
S$2947  (via drill 0.2)
  other vias: 40.4,86
S$2948  (via drill 0.2)
  other vias: 38.8,86
S$2949  (via drill 0.2)
  other vias: 37.2,86
S$2950  (via drill 0.2)
  other vias: 35.6,86
S$2951  (via drill 0.2)
  other vias: 34,90
S$2952  (via drill 0.2)
  other vias: 32.4,90
S$2953  (via drill 0.2)
  other vias: 30.8,90
S$2954  (via drill 0.2)
  other vias: 33.2,94
S$2955  (via drill 0.2)
  other vias: 31.6,94
S$2956  (via drill 0.2)
  other vias: 30,94
S$2957  (via drill 0.2)
  other vias: 29.2,90
S$2958  (via drill 0.2)
  other vias: 28.4,94
S$2959  (via drill 0.2)
  other vias: 27.6,90
S$2960  (via drill 0.2)
  other vias: 26.8,94
S$2961  (via drill 0.2)
  other vias: 26,90
S$2962
  Bottom 0.152: -52.8,95 -51.8,94
S$2963
  Bottom 0.152: -51.8,94 -50.8,94
S$2964
  Bottom 0.152: -50.8,95 -50.2,95
S$2965
  Bottom 0.152: -50.2,95 -49.2,94
S$2966
  Bottom 0.152: -48.8,95 -48.6,95
S$2967
  Bottom 0.152: -48.6,95 -47.6,94
S$2968
  Bottom 0.152: -46.8,95 -46,94.2
S$2969
  Bottom 0.152: -46,94.2 -46,94
S$2970
  Bottom 0.152: -44.8,95 -44.4,94.6
S$2971
  Bottom 0.152: -44.4,94.6 -44.4,94
S$2972
  Bottom 0.152: -42.8,95 -42.8,94
S$2973
  Bottom 0.152: -40.8,95 -41.2,94.6
S$2974
  Bottom 0.152: -41.2,94.6 -41.2,94
S$2975
  Bottom 0.152: -38.8,95 -39.6,94.2
S$2976
  Bottom 0.152: -39.6,94.2 -39.6,94
S$2977
  Bottom 0.152: -36.8,95 -37,95
S$2978
  Bottom 0.152: -37,95 -38,94
S$2979
  Bottom 0.152: -34.8,95 -35.4,95
S$2980
  Bottom 0.152: -35.4,95 -36.4,94
S$2981
  Bottom 0.152: -32.8,95 -33.8,94
S$2982
  Bottom 0.152: -33.8,94 -34.8,94
S$2983
  Bottom 0.152: -51.8,91 -50.8,90
S$2984
  Bottom 0.152: -50.8,90 -50,90
S$2985
  Bottom 0.152: -49.8,91 -48.8,90
S$2986
  Bottom 0.152: -48.8,90 -48.4,90
S$2987
  Bottom 0.152: -47.8,91 -46.8,90
S$2988
  Bottom 0.152: -45.8,91 -45.2,90.4
S$2989
  Bottom 0.152: -45.2,90.4 -45.2,90
S$2990
  Bottom 0.152: -43.8,91 -43.6,90.8
S$2991
  Bottom 0.152: -43.6,90.8 -43.6,90
S$2992
  Bottom 0.152: -41.8,91 -42,90.8
S$2993
  Bottom 0.152: -42,90.8 -42,90
S$2994
  Bottom 0.152: -39.8,91 -40.4,90.4
S$2995
  Bottom 0.152: -40.4,90.4 -40.4,90
S$2996
  Bottom 0.152: -37.8,91 -38.8,90
S$2997
  Bottom 0.152: -35.8,91 -36.8,90
S$2998
  Bottom 0.152: -36.8,90 -37.2,90
S$2999
  Bottom 0.152: -33.8,91 -34.8,90
S$3000
  Bottom 0.152: -34.8,90 -35.6,90
S$3001
  Bottom 0.152: -36.6,85 -35.6,86
S$3002
  Bottom 0.152: -35.6,86 -34,86
S$3003
  Bottom 0.152: -34.6,85 -33.8,85
S$3004
  Bottom 0.152: -33.8,85 -32.8,86
S$3005
  Bottom 0.152: -32.8,86 -32.4,86
S$3006
  Bottom 0.152: -32.6,85 -31.8,85
S$3007
  Bottom 0.152: -31.8,85 -30.8,86
S$3008
  Bottom 0.152: -30.6,85 -30.2,85
S$3009
  Bottom 0.152: -30.2,85 -29.2,86
S$3010
  Bottom 0.152: -28.6,85 -27.6,86
S$3011
  Bottom 0.152: -26.6,85 -26,85.6
S$3012
  Bottom 0.152: -26,85.6 -26,86
S$3013
  Bottom 0.152: -35.6,89 -35,89
S$3014
  Bottom 0.152: -35,89 -34,90
S$3015
  Bottom 0.152: -34,90 -33.2,90
S$3016
  Bottom 0.152: -33.6,89 -33,89
S$3017
  Bottom 0.152: -33,89 -32,90
S$3018
  Bottom 0.152: -32,90 -31.6,90
S$3019
  Bottom 0.152: -31.6,89 -31,89
S$3020
  Bottom 0.152: -31,89 -30,90
S$3021
  Bottom 0.152: -29.6,89 -29.4,89
S$3022
  Bottom 0.152: -29.4,89 -28.4,90
S$3023
  Bottom 0.152: -27.6,89 -26.8,89.8
S$3024
  Bottom 0.152: -26.8,89.8 -26.8,90
S$3025
  Bottom 0.152: 1.6,95 0.6,94
S$3026
  Bottom 0.152: 0.6,94 -0.4,94
S$3027
  Bottom 0.152: -0.4,95 -1,95
S$3028
  Bottom 0.152: -1,95 -2,94
S$3029
  Bottom 0.152: -2.4,95 -2.6,95
S$3030
  Bottom 0.152: -2.6,95 -3.6,94
S$3031
  Bottom 0.152: -4.4,95 -5.2,94.2
S$3032
  Bottom 0.152: -5.2,94.2 -5.2,94
S$3033
  Bottom 0.152: -6.4,95 -6.8,94.6
S$3034
  Bottom 0.152: -6.8,94.6 -6.8,94
S$3035
  Bottom 0.152: -8.4,95 -8.4,94
S$3036
  Bottom 0.152: -10.4,95 -10,94.6
S$3037
  Bottom 0.152: -10,94.6 -10,94
S$3038
  Bottom 0.152: -12.4,95 -11.6,94.2
S$3039
  Bottom 0.152: -11.6,94.2 -11.6,94
S$3040
  Bottom 0.152: -14.4,95 -14.2,95
S$3041
  Bottom 0.152: -14.2,95 -13.2,94
S$3042
  Bottom 0.152: -16.4,95 -15.8,95
S$3043
  Bottom 0.152: -15.8,95 -14.8,94
S$3044
  Bottom 0.152: -18.4,95 -17.4,94
S$3045
  Bottom 0.152: -17.4,94 -16.4,94
S$3046
  Bottom 0.152: 0.6,91 -0.4,90
S$3047
  Bottom 0.152: -0.4,90 -1.2,90
S$3048
  Bottom 0.152: -1.4,91 -2.4,90
S$3049
  Bottom 0.152: -2.4,90 -2.8,90
S$3050
  Bottom 0.152: -3.4,91 -4.4,90
S$3051
  Bottom 0.152: -5.4,91 -6,90.4
S$3052
  Bottom 0.152: -6,90.4 -6,90
S$3053
  Bottom 0.152: -7.4,91 -7.6,90.8
S$3054
  Bottom 0.152: -7.6,90.8 -7.6,90
S$3055
  Bottom 0.152: -9.4,91 -9.2,90.8
S$3056
  Bottom 0.152: -9.2,90.8 -9.2,90
S$3057
  Bottom 0.152: -11.4,91 -10.8,90.4
S$3058
  Bottom 0.152: -10.8,90.4 -10.8,90
S$3059
  Bottom 0.152: -13.4,91 -12.4,90
S$3060
  Bottom 0.152: -15.4,91 -14.4,90
S$3061
  Bottom 0.152: -14.4,90 -14,90
S$3062
  Bottom 0.152: -17.4,91 -16.4,90
S$3063
  Bottom 0.152: -16.4,90 -15.6,90
S$3064
  Bottom 0.152: -14.6,85 -15.6,86
S$3065
  Bottom 0.152: -15.6,86 -17.2,86
S$3066
  Bottom 0.152: -16.6,85 -17.4,85
S$3067
  Bottom 0.152: -17.4,85 -18.4,86
S$3068
  Bottom 0.152: -18.4,86 -18.8,86
S$3069
  Bottom 0.152: -18.6,85 -19.4,85
S$3070
  Bottom 0.152: -19.4,85 -20.4,86
S$3071
  Bottom 0.152: -20.6,85 -21,85
S$3072
  Bottom 0.152: -21,85 -22,86
S$3073
  Bottom 0.152: -22.6,85 -23.6,86
S$3074
  Bottom 0.152: -24.6,85 -25.2,85.6
S$3075
  Bottom 0.152: -25.2,85.6 -25.2,86
S$3076
  Bottom 0.152: -15.6,89 -16.2,89
S$3077
  Bottom 0.152: -16.2,89 -17.2,90
S$3078
  Bottom 0.152: -17.2,90 -18,90
S$3079
  Bottom 0.152: -17.6,89 -18.2,89
S$3080
  Bottom 0.152: -18.2,89 -19.2,90
S$3081
  Bottom 0.152: -19.2,90 -19.6,90
S$3082
  Bottom 0.152: -19.6,89 -20.2,89
S$3083
  Bottom 0.152: -20.2,89 -21.2,90
S$3084
  Bottom 0.152: -21.6,89 -21.8,89
S$3085
  Bottom 0.152: -21.8,89 -22.8,90
S$3086
  Bottom 0.152: -23.6,89 -24.4,89.8
S$3087
  Bottom 0.152: -24.4,89.8 -24.4,90
S$3088
  Bottom 0.152: 0.4,89 1,89
S$3089
  Bottom 0.152: 1,89 2,90
S$3090
  Bottom 0.152: 2.4,89 2.6,89
S$3091
  Bottom 0.152: 2.6,89 3.6,90
S$3092
  Bottom 0.152: 4.4,89 5.2,89.8
S$3093
  Bottom 0.152: 5.2,89.8 5.2,90
S$3094
  Bottom 0.152: 6.4,89 6.8,89.4
S$3095
  Bottom 0.152: 6.8,89.4 6.8,90
S$3096
  Bottom 0.152: 8.4,89 8.4,90
S$3097
  Bottom 0.152: -1.6,89 -0.6,89
S$3098
  Bottom 0.152: -0.6,89 0.4,90
S$3099
  Bottom 0.152: -0.6,85 0.4,86
S$3100
  Bottom 0.152: 0.4,86 1.2,86
S$3101
  Bottom 0.152: 1.4,85 1.8,85
S$3102
  Bottom 0.152: 1.8,85 2.8,86
S$3103
  Bottom 0.152: 3.4,85 4.4,86
S$3104
  Bottom 0.152: 5.4,85 6,85.6
S$3105
  Bottom 0.152: 6,85.6 6,86
S$3106
  Bottom 0.152: 7.4,85 7.6,85.2
S$3107
  Bottom 0.152: 7.6,85.2 7.6,86
S$3108
  Bottom 0.152: 9.4,85 9.2,85.2
S$3109
  Bottom 0.152: 9.2,85.2 9.2,86
S$3110
  Bottom 0.152: 11.4,85 10.8,85.6
S$3111
  Bottom 0.152: 10.8,85.6 10.8,86
S$3112
  Bottom 0.152: 13.4,85 12.4,86
S$3113
  Bottom 0.152: 15.4,85 15,85
S$3114
  Bottom 0.152: 15,85 14,86
S$3115
  Bottom 0.152: 17.4,85 16.6,85
S$3116
  Bottom 0.152: 16.6,85 15.6,86
S$3117
  Bottom 0.152: 10.4,89 10,89.4
S$3118
  Bottom 0.152: 10,89.4 10,90
S$3119
  Bottom 0.152: 12.4,89 11.6,89.8
S$3120
  Bottom 0.152: 11.6,89.8 11.6,90
S$3121
  Bottom 0.152: 14.4,89 14.2,89
S$3122
  Bottom 0.152: 14.2,89 13.2,90
S$3123
  Bottom 0.152: 16.4,89 15.8,89
S$3124
  Bottom 0.152: 15.8,89 14.8,90
S$3125
  Bottom 0.152: 18.4,87 17.4,86
S$3126
  Bottom 0.152: 17.4,86 16.4,86
S$3127
  Bottom 0.152: 16.6,91 17.2,91
S$3128
  Bottom 0.152: 17.2,91 18.2,90
S$3129
  Bottom 0.152: 18.2,90 18.8,90
S$3130
  Bottom 0.152: 18.6,91 19.6,90
S$3131
  Bottom 0.152: 19.6,90 20.4,90
S$3132
  Bottom 0.152: 20.6,91 21.6,90
S$3133
  Bottom 0.152: 21.6,90 22,90
S$3134
  Bottom 0.152: 22.6,91 23.6,90
S$3135
  Bottom 0.152: 24.6,91 25.2,90.4
S$3136
  Bottom 0.152: 25.2,90.4 25.2,90
S$3137
  Bottom 0.152: 15.6,95 16.6,94
S$3138
  Bottom 0.152: 16.6,94 18,94
S$3139
  Bottom 0.152: 17.6,95 18,95
S$3140
  Bottom 0.152: 18,95 19,94
S$3141
  Bottom 0.152: 19,94 19.6,94
S$3142
  Bottom 0.152: 19.6,95 20.2,95
S$3143
  Bottom 0.152: 20.2,95 21.2,94
S$3144
  Bottom 0.152: 21.6,95 21.8,95
S$3145
  Bottom 0.152: 21.8,95 22.8,94
S$3146
  Bottom 0.152: 23.6,95 24.4,94.2
S$3147
  Bottom 0.152: 24.4,94.2 24.4,94
S$3148
  Bottom 0.152: 17.2,90 16,90
S$3149
  Bottom 0.152: 16,90 15,91
S$3150
  Bottom 0.152: 15,91 14.6,91
S$3151
  Bottom 0.152: 50.8,89 50.2,89
S$3152
  Bottom 0.152: 50.2,89 49.2,90
S$3153
  Bottom 0.152: 48.8,89 48.6,89
S$3154
  Bottom 0.152: 48.6,89 47.6,90
S$3155
  Bottom 0.152: 46.8,89 46,89.8
S$3156
  Bottom 0.152: 46,89.8 46,90
S$3157
  Bottom 0.152: 44.8,89 44.4,89.4
S$3158
  Bottom 0.152: 44.4,89.4 44.4,90
S$3159
  Bottom 0.152: 42.8,89 42.8,90
S$3160
  Bottom 0.152: 52.8,89 51.8,89
S$3161
  Bottom 0.152: 51.8,89 50.8,90
S$3162
  Bottom 0.152: 51.8,85 50.8,86
S$3163
  Bottom 0.152: 50.8,86 50,86
S$3164
  Bottom 0.152: 49.8,85 49.4,85
S$3165
  Bottom 0.152: 49.4,85 48.4,86
S$3166
  Bottom 0.152: 47.8,85 46.8,86
S$3167
  Bottom 0.152: 45.8,85 45.2,85.6
S$3168
  Bottom 0.152: 45.2,85.6 45.2,86
S$3169
  Bottom 0.152: 43.8,85 43.6,85.2
S$3170
  Bottom 0.152: 43.6,85.2 43.6,86
S$3171
  Bottom 0.152: 41.8,85 42,85.2
S$3172
  Bottom 0.152: 42,85.2 42,86
S$3173
  Bottom 0.152: 39.8,85 40.4,85.6
S$3174
  Bottom 0.152: 40.4,85.6 40.4,86
S$3175
  Bottom 0.152: 37.8,85 38.8,86
S$3176
  Bottom 0.152: 35.8,85 36.2,85
S$3177
  Bottom 0.152: 36.2,85 37.2,86
S$3178
  Bottom 0.152: 33.8,85 34.6,85
S$3179
  Bottom 0.152: 34.6,85 35.6,86
S$3180
  Bottom 0.152: 40.8,89 41.2,89.4
S$3181
  Bottom 0.152: 41.2,89.4 41.2,90
S$3182
  Bottom 0.152: 38.8,89 39.6,89.8
S$3183
  Bottom 0.152: 39.6,89.8 39.6,90
S$3184
  Bottom 0.152: 36.8,89 37,89
S$3185
  Bottom 0.152: 37,89 38,90
S$3186
  Bottom 0.152: 34.8,89 35.4,89
S$3187
  Bottom 0.152: 35.4,89 36.4,90
S$3188
  Bottom 0.152: 32.8,87 33.8,86
S$3189
  Bottom 0.152: 33.8,86 34.8,86
S$3190
  Bottom 0.152: 34.6,91 34,91
S$3191
  Bottom 0.152: 34,91 33,90
S$3192
  Bottom 0.152: 33,90 32.4,90
S$3193
  Bottom 0.152: 32.6,91 31.6,90
S$3194
  Bottom 0.152: 31.6,90 30.8,90
S$3195
  Bottom 0.152: 30.6,91 29.6,90
S$3196
  Bottom 0.152: 29.6,90 29.2,90
S$3197
  Bottom 0.152: 28.6,91 27.6,90
S$3198
  Bottom 0.152: 26.6,91 26,90.4
S$3199
  Bottom 0.152: 26,90.4 26,90
S$3200
  Bottom 0.152: 35.6,95 34.6,94
S$3201
  Bottom 0.152: 34.6,94 33.2,94
S$3202
  Bottom 0.152: 33.6,95 33.2,95
S$3203
  Bottom 0.152: 33.2,95 32.2,94
S$3204
  Bottom 0.152: 32.2,94 31.6,94
S$3205
  Bottom 0.152: 31.6,95 31,95
S$3206
  Bottom 0.152: 31,95 30,94
S$3207
  Bottom 0.152: 29.6,95 29.4,95
S$3208
  Bottom 0.152: 29.4,95 28.4,94
S$3209
  Bottom 0.152: 27.6,95 26.8,94.2
S$3210
  Bottom 0.152: 26.8,94.2 26.8,94
S$3211
  Bottom 0.152: 34,90 35.2,90
S$3212
  Bottom 0.152: 35.2,90 36.2,91
S$3213
  Bottom 0.152: 36.2,91 36.6,91
S$3214  (2 unrouted)
  Top 0.813: 65,94.5 65,85.5
  Top 1.8: 66,91.5 64,91.5 | 66,94.5 65,94.5 64,94.5 | 66,88.5 64,88.5 | 66,85.5 65,85.5 64,85.5
S$3215
  Top 1.778: -104.08,86.83 -104.08,88.35
S$3216
  Top 1.778: -104.08,91.65 -104.08,93.17
S$3217
  Top 1.778: -99,86.83 -99,88.35
S$3218
  Top 1.778: -99,91.65 -99,93.17
S$3219
  Top 1.778: -93.92,86.83 -93.92,88.35
S$3220
  Top 1.778: -93.92,91.65 -93.92,93.17
S$3221
  Top 1.778: 93.92,86.83 93.92,88.35
S$3222
  Top 1.778: 93.92,91.65 93.92,93.17
S$3223
  Top 1.778: 99,86.83 99,88.35
S$3224
  Top 1.778: 99,91.65 99,93.17
S$3225
  Top 1.778: 104.08,86.83 104.08,88.35
S$3226
  Top 1.778: 104.08,91.65 104.08,93.17
S$3227  (via drill 0.2)
  other vias: -25.6,96.4
S$3228  (via drill 0.2)
  other vias: -8.6,83.6
S$3229  (via drill 0.2)
  other vias: 8.6,96.4
S$3230  (via drill 0.2)
  other vias: 25.6,83.6
S$3231  (via drill 0.2)
  other vias: 41.6,96.4
S$3232  (via drill 0.2)
  other vias: 52.8,96.4
S$3233  (via drill 0.2)
  other vias: -41.6,83.6
S$3234  (via drill 0.2)
  other vias: -52.8,83.6
S$3235
  Bottom 0.8: 9.4,102.9 9.4,101.1
S$3236
  Bottom 0.8: 11.4,102.9 11.4,101.1
S$3237
  Bottom 0.8: 8.4,105.1 8.4,106.9
S$3238
  Bottom 0.8: 10.4,105.1 10.4,106.9
S$3239
  Bottom 0.8: 5.4,102.9 5.4,101.1
S$3240
  Bottom 0.8: 7.4,102.9 7.4,101.1
S$3241
  Bottom 0.8: 6.4,105.1 6.4,106.9
S$3242
  Bottom 0.8: 4.4,105.1 4.4,106.9
S$3243
  Bottom 0.8: 3.4,102.9 3.4,101.1
S$3244
  Bottom 0.8: 1.4,102.9 1.4,101.1
S$3245
  Bottom 0.8: 2.4,105.1 2.4,106.9
S$3246
  Bottom 0.8: 0.4,105.1 0.4,106.9
S$3247
  Bottom 0.8: -0.6,102.9 -0.6,101.1
S$3248
  Bottom 0.8: -2.6,102.9 -2.6,101.1
S$3249
  Bottom 0.8: -1.6,105.1 -1.6,106.9
S$3250
  Bottom 0.8: 17.4,102.9 17.4,101.1
S$3251
  Bottom 0.8: 19.4,102.9 19.4,101.1
S$3252
  Bottom 0.8: 16.4,105.1 16.4,106.9
S$3253
  Bottom 0.8: 18.4,105.1 18.4,106.9
S$3254
  Bottom 0.8: 13.4,102.9 13.4,101.1
S$3255
  Bottom 0.8: 15.4,102.9 15.4,101.1
S$3256
  Bottom 0.8: 12.4,105.1 12.4,106.9
S$3257
  Bottom 0.8: 14.4,105.1 14.4,106.9
S$3258
  Bottom 0.8: -7.4,110.9 -7.4,109.1
S$3259
  Bottom 0.8: -5.4,110.9 -5.4,109.1
S$3260
  Bottom 0.8: -8.4,113.1 -8.4,114.9
S$3261
  Bottom 0.8: -6.4,113.1 -6.4,114.9
S$3262
  Bottom 0.8: -11.4,110.9 -11.4,109.1
S$3263
  Bottom 0.8: -9.4,110.9 -9.4,109.1
S$3264
  Bottom 0.8: -10.4,113.1 -10.4,114.9
S$3265
  Bottom 0.8: -12.4,113.1 -12.4,114.9
S$3266
  Bottom 0.8: -13.4,110.9 -13.4,109.1
S$3267
  Bottom 0.8: -15.4,110.9 -15.4,109.1
S$3268
  Bottom 0.8: -14.4,113.1 -14.4,114.9
S$3269
  Bottom 0.8: -16.4,113.1 -16.4,114.9
S$3270
  Bottom 0.8: -17.4,110.9 -17.4,109.1
S$3271
  Bottom 0.8: -19.4,110.9 -19.4,109.1
S$3272
  Bottom 0.8: -18.4,113.1 -18.4,114.9
S$3273
  Bottom 0.8: 0.6,110.9 0.6,109.1
S$3274
  Bottom 0.8: 2.6,110.9 2.6,109.1
S$3275
  Bottom 0.8: -0.4,113.1 -0.4,114.9
S$3276
  Bottom 0.8: 1.6,113.1 1.6,114.9
S$3277
  Bottom 0.8: -3.4,110.9 -3.4,109.1
S$3278
  Bottom 0.8: -1.4,110.9 -1.4,109.1
S$3279
  Bottom 0.8: -4.4,113.1 -4.4,114.9
S$3280
  Bottom 0.8: -2.4,113.1 -2.4,114.9
S$3281
  Bottom 0.8: -24.6,102.9 -24.6,101.1
S$3282
  Bottom 0.8: -22.6,102.9 -22.6,101.1
S$3283
  Bottom 0.8: -25.6,105.1 -25.6,106.9
S$3284
  Bottom 0.8: -23.6,105.1 -23.6,106.9
S$3285
  Bottom 0.8: -28.6,102.9 -28.6,101.1
S$3286
  Bottom 0.8: -26.6,102.9 -26.6,101.1
S$3287
  Bottom 0.8: -27.6,105.1 -27.6,106.9
S$3288
  Bottom 0.8: -29.6,105.1 -29.6,106.9
S$3289
  Bottom 0.8: -30.6,102.9 -30.6,101.1
S$3290
  Bottom 0.8: -32.6,102.9 -32.6,101.1
S$3291
  Bottom 0.8: -31.6,105.1 -31.6,106.9
S$3292
  Bottom 0.8: -33.6,105.1 -33.6,106.9
S$3293
  Bottom 0.8: -34.6,102.9 -34.6,101.1
S$3294
  Bottom 0.8: -36.6,102.9 -36.6,101.1
S$3295
  Bottom 0.8: -35.6,105.1 -35.6,106.9
S$3296
  Bottom 0.8: -16.6,102.9 -16.6,101.1
S$3297
  Bottom 0.8: -14.6,102.9 -14.6,101.1
S$3298
  Bottom 0.8: -17.6,105.1 -17.6,106.9
S$3299
  Bottom 0.8: -15.6,105.1 -15.6,106.9
S$3300
  Bottom 0.8: -20.6,102.9 -20.6,101.1
S$3301
  Bottom 0.8: -18.6,102.9 -18.6,101.1
S$3302
  Bottom 0.8: -21.6,105.1 -21.6,106.9
S$3303
  Bottom 0.8: -19.6,105.1 -19.6,106.9
S$3304
  Bottom 0.8: 26.6,110.9 26.6,109.1
S$3305
  Bottom 0.8: 28.6,110.9 28.6,109.1
S$3306
  Bottom 0.8: 25.6,113.1 25.6,114.9
S$3307
  Bottom 0.8: 27.6,113.1 27.6,114.9
S$3308
  Bottom 0.8: 22.6,110.9 22.6,109.1
S$3309
  Bottom 0.8: 24.6,110.9 24.6,109.1
S$3310
  Bottom 0.8: 23.6,113.1 23.6,114.9
S$3311
  Bottom 0.8: 21.6,113.1 21.6,114.9
S$3312
  Bottom 0.8: 20.6,110.9 20.6,109.1
S$3313
  Bottom 0.8: 18.6,110.9 18.6,109.1
S$3314
  Bottom 0.8: 19.6,113.1 19.6,114.9
S$3315
  Bottom 0.8: 17.6,113.1 17.6,114.9
S$3316
  Bottom 0.8: 16.6,110.9 16.6,109.1
S$3317
  Bottom 0.8: 14.6,110.9 14.6,109.1
S$3318
  Bottom 0.8: 15.6,113.1 15.6,114.9
S$3319
  Bottom 0.8: 34.6,110.9 34.6,109.1
S$3320
  Bottom 0.8: 36.6,110.9 36.6,109.1
S$3321
  Bottom 0.8: 33.6,113.1 33.6,114.9
S$3322
  Bottom 0.8: 35.6,113.1 35.6,114.9
S$3323
  Bottom 0.8: 30.6,110.9 30.6,109.1
S$3324
  Bottom 0.8: 32.6,110.9 32.6,109.1
S$3325
  Bottom 0.8: 29.6,113.1 29.6,114.9
S$3326
  Bottom 0.8: 31.6,113.1 31.6,114.9
S$3327
  Bottom 0.8: -41.8,110.9 -41.8,109.1
S$3328
  Bottom 0.8: -39.8,110.9 -39.8,109.1
S$3329
  Bottom 0.8: -42.8,113.1 -42.8,114.9
S$3330
  Bottom 0.8: -40.8,113.1 -40.8,114.9
S$3331
  Bottom 0.8: -45.8,110.9 -45.8,109.1
S$3332
  Bottom 0.8: -43.8,110.9 -43.8,109.1
S$3333
  Bottom 0.8: -44.8,113.1 -44.8,114.9
S$3334
  Bottom 0.8: -46.8,113.1 -46.8,114.9
S$3335
  Bottom 0.8: -47.8,110.9 -47.8,109.1
S$3336
  Bottom 0.8: -49.8,110.9 -49.8,109.1
S$3337
  Bottom 0.8: -48.8,113.1 -48.8,114.9
S$3338
  Bottom 0.8: -50.8,113.1 -50.8,114.9
S$3339
  Bottom 0.8: -51.8,110.9 -51.8,109.1
S$3340
  Bottom 0.8: -53.8,110.9 -53.8,109.1
S$3341
  Bottom 0.8: -52.8,113.1 -52.8,114.9
S$3342
  Bottom 0.8: -33.8,110.9 -33.8,109.1
S$3343
  Bottom 0.8: -31.8,110.9 -31.8,109.1
S$3344
  Bottom 0.8: -34.8,113.1 -34.8,114.9
S$3345
  Bottom 0.8: -32.8,113.1 -32.8,114.9
S$3346
  Bottom 0.8: -37.8,110.9 -37.8,109.1
S$3347
  Bottom 0.8: -35.8,110.9 -35.8,109.1
S$3348
  Bottom 0.8: -38.8,113.1 -38.8,114.9
S$3349
  Bottom 0.8: -36.8,113.1 -36.8,114.9
S$3350
  Bottom 0.8: 43.8,102.9 43.8,101.1
S$3351
  Bottom 0.8: 45.8,102.9 45.8,101.1
S$3352
  Bottom 0.8: 42.8,105.1 42.8,106.9
S$3353
  Bottom 0.8: 44.8,105.1 44.8,106.9
S$3354
  Bottom 0.8: 39.8,102.9 39.8,101.1
S$3355
  Bottom 0.8: 41.8,102.9 41.8,101.1
S$3356
  Bottom 0.8: 40.8,105.1 40.8,106.9
S$3357
  Bottom 0.8: 38.8,105.1 38.8,106.9
S$3358
  Bottom 0.8: 37.8,102.9 37.8,101.1
S$3359
  Bottom 0.8: 35.8,102.9 35.8,101.1
S$3360
  Bottom 0.8: 36.8,105.1 36.8,106.9
S$3361
  Bottom 0.8: 34.8,105.1 34.8,106.9
S$3362
  Bottom 0.8: 33.8,102.9 33.8,101.1
S$3363
  Bottom 0.8: 31.8,102.9 31.8,101.1
S$3364
  Bottom 0.8: 32.8,105.1 32.8,106.9
S$3365
  Bottom 0.8: 51.8,102.9 51.8,101.1
S$3366
  Bottom 0.8: 53.8,102.9 53.8,101.1
S$3367
  Bottom 0.8: 50.8,105.1 50.8,106.9
S$3368
  Bottom 0.8: 52.8,105.1 52.8,106.9
S$3369
  Bottom 0.8: 47.8,102.9 47.8,101.1
S$3370
  Bottom 0.8: 49.8,102.9 49.8,101.1
S$3371
  Bottom 0.8: 46.8,105.1 46.8,106.9
S$3372
  Bottom 0.8: 48.8,105.1 48.8,106.9
S$3373  (via drill 0.2)
  other vias: -50.8,112
S$3374  (via drill 0.2)
  other vias: -49.2,112
S$3375  (via drill 0.2)
  other vias: -47.6,112
S$3376  (via drill 0.2)
  other vias: -46,112
S$3377  (via drill 0.2)
  other vias: -44.4,112
S$3378  (via drill 0.2)
  other vias: -42.8,112
S$3379  (via drill 0.2)
  other vias: -41.2,112
S$3380  (via drill 0.2)
  other vias: -39.6,112
S$3381  (via drill 0.2)
  other vias: -38,112
S$3382  (via drill 0.2)
  other vias: -36.4,112
S$3383  (via drill 0.2)
  other vias: -34.8,112
S$3384  (via drill 0.2)
  other vias: -50,108
S$3385  (via drill 0.2)
  other vias: -48.4,108
S$3386  (via drill 0.2)
  other vias: -46.8,108
S$3387  (via drill 0.2)
  other vias: -45.2,108
S$3388  (via drill 0.2)
  other vias: -43.6,108
S$3389  (via drill 0.2)
  other vias: -42,108
S$3390  (via drill 0.2)
  other vias: -40.4,108
S$3391  (via drill 0.2)
  other vias: -38.8,108
S$3392  (via drill 0.2)
  other vias: -37.2,108
S$3393  (via drill 0.2)
  other vias: -35.6,108
S$3394  (via drill 0.2)
  other vias: -34,104
S$3395  (via drill 0.2)
  other vias: -32.4,104
S$3396  (via drill 0.2)
  other vias: -30.8,104
S$3397  (via drill 0.2)
  other vias: -29.2,104
S$3398  (via drill 0.2)
  other vias: -27.6,104
S$3399  (via drill 0.2)
  other vias: -33.2,108
S$3400  (via drill 0.2)
  other vias: -31.6,108
S$3401  (via drill 0.2)
  other vias: -30,108
S$3402  (via drill 0.2)
  other vias: -28.4,108
S$3403  (via drill 0.2)
  other vias: -26.8,108
S$3404  (via drill 0.2)
  other vias: -26,104
S$3405  (via drill 0.2)
  other vias: -0.4,112
S$3406  (via drill 0.2)
  other vias: -2,112
S$3407  (via drill 0.2)
  other vias: -3.6,112
S$3408  (via drill 0.2)
  other vias: -5.2,112
S$3409  (via drill 0.2)
  other vias: -6.8,112
S$3410  (via drill 0.2)
  other vias: -8.4,112
S$3411  (via drill 0.2)
  other vias: -10,112
S$3412  (via drill 0.2)
  other vias: -11.6,112
S$3413  (via drill 0.2)
  other vias: -13.2,112
S$3414  (via drill 0.2)
  other vias: -14.8,112
S$3415  (via drill 0.2)
  other vias: -16.4,112
S$3416  (via drill 0.2)
  other vias: -1.2,108
S$3417  (via drill 0.2)
  other vias: -2.8,108
S$3418  (via drill 0.2)
  other vias: -4.4,108
S$3419  (via drill 0.2)
  other vias: -6,108
S$3420  (via drill 0.2)
  other vias: -7.6,108
S$3421  (via drill 0.2)
  other vias: -9.2,108
S$3422  (via drill 0.2)
  other vias: -10.8,108
S$3423  (via drill 0.2)
  other vias: -12.4,108
S$3424  (via drill 0.2)
  other vias: -14,108
S$3425  (via drill 0.2)
  other vias: -15.6,108
S$3426  (via drill 0.2)
  other vias: -17.2,104
S$3427  (via drill 0.2)
  other vias: -18.8,104
S$3428  (via drill 0.2)
  other vias: -20.4,104
S$3429  (via drill 0.2)
  other vias: -22,104
S$3430  (via drill 0.2)
  other vias: -23.6,104
S$3431  (via drill 0.2)
  other vias: -18,108
S$3432  (via drill 0.2)
  other vias: -19.6,108
S$3433  (via drill 0.2)
  other vias: -21.2,108
S$3434  (via drill 0.2)
  other vias: -22.8,108
S$3435  (via drill 0.2)
  other vias: -24.4,108
S$3436  (via drill 0.2)
  other vias: -25.2,104
S$3437  (via drill 0.2)
  other vias: 0.4,108
S$3438  (via drill 0.2)
  other vias: 2,108
S$3439  (via drill 0.2)
  other vias: 3.6,108
S$3440  (via drill 0.2)
  other vias: 5.2,108
S$3441  (via drill 0.2)
  other vias: 6.8,108
S$3442  (via drill 0.2)
  other vias: 8.4,108
S$3443  (via drill 0.2)
  other vias: 10,108
S$3444  (via drill 0.2)
  other vias: 11.6,108
S$3445  (via drill 0.2)
  other vias: 13.2,108
S$3446  (via drill 0.2)
  other vias: 14.8,108
S$3447  (via drill 0.2)
  other vias: 16.4,104
S$3448  (via drill 0.2)
  other vias: 1.2,104
S$3449  (via drill 0.2)
  other vias: 2.8,104
S$3450  (via drill 0.2)
  other vias: 4.4,104
S$3451  (via drill 0.2)
  other vias: 6,104
S$3452  (via drill 0.2)
  other vias: 7.6,104
S$3453  (via drill 0.2)
  other vias: 9.2,104
S$3454  (via drill 0.2)
  other vias: 10.8,104
S$3455  (via drill 0.2)
  other vias: 12.4,104
S$3456  (via drill 0.2)
  other vias: 14,104
S$3457  (via drill 0.2)
  other vias: 15.6,104
S$3458  (via drill 0.2)
  other vias: 17.2,108
S$3459  (via drill 0.2)
  other vias: 18.8,108
S$3460  (via drill 0.2)
  other vias: 20.4,108
S$3461  (via drill 0.2)
  other vias: 18,112
S$3462  (via drill 0.2)
  other vias: 19.6,112
S$3463  (via drill 0.2)
  other vias: 21.2,112
S$3464  (via drill 0.2)
  other vias: 22,108
S$3465  (via drill 0.2)
  other vias: 22.8,112
S$3466  (via drill 0.2)
  other vias: 23.6,108
S$3467  (via drill 0.2)
  other vias: 24.4,112
S$3468  (via drill 0.2)
  other vias: 25.2,108
S$3469  (via drill 0.2)
  other vias: 50.8,108
S$3470  (via drill 0.2)
  other vias: 49.2,108
S$3471  (via drill 0.2)
  other vias: 47.6,108
S$3472  (via drill 0.2)
  other vias: 46,108
S$3473  (via drill 0.2)
  other vias: 44.4,108
S$3474  (via drill 0.2)
  other vias: 42.8,108
S$3475  (via drill 0.2)
  other vias: 41.2,108
S$3476  (via drill 0.2)
  other vias: 39.6,108
S$3477  (via drill 0.2)
  other vias: 38,108
S$3478  (via drill 0.2)
  other vias: 36.4,108
S$3479  (via drill 0.2)
  other vias: 34.8,104
S$3480  (via drill 0.2)
  other vias: 50,104
S$3481  (via drill 0.2)
  other vias: 48.4,104
S$3482  (via drill 0.2)
  other vias: 46.8,104
S$3483  (via drill 0.2)
  other vias: 45.2,104
S$3484  (via drill 0.2)
  other vias: 43.6,104
S$3485  (via drill 0.2)
  other vias: 42,104
S$3486  (via drill 0.2)
  other vias: 40.4,104
S$3487  (via drill 0.2)
  other vias: 38.8,104
S$3488  (via drill 0.2)
  other vias: 37.2,104
S$3489  (via drill 0.2)
  other vias: 35.6,104
S$3490  (via drill 0.2)
  other vias: 34,108
S$3491  (via drill 0.2)
  other vias: 32.4,108
S$3492  (via drill 0.2)
  other vias: 30.8,108
S$3493  (via drill 0.2)
  other vias: 33.2,112
S$3494  (via drill 0.2)
  other vias: 31.6,112
S$3495  (via drill 0.2)
  other vias: 30,112
S$3496  (via drill 0.2)
  other vias: 29.2,108
S$3497  (via drill 0.2)
  other vias: 28.4,112
S$3498  (via drill 0.2)
  other vias: 27.6,108
S$3499  (via drill 0.2)
  other vias: 26.8,112
S$3500  (via drill 0.2)
  other vias: 26,108
S$3501
  Bottom 0.152: -52.8,113 -51.8,112
S$3502
  Bottom 0.152: -51.8,112 -50.8,112
S$3503
  Bottom 0.152: -50.8,113 -50.2,113
S$3504
  Bottom 0.152: -50.2,113 -49.2,112
S$3505
  Bottom 0.152: -48.8,113 -48.6,113
S$3506
  Bottom 0.152: -48.6,113 -47.6,112
S$3507
  Bottom 0.152: -46.8,113 -46,112.2
S$3508
  Bottom 0.152: -46,112.2 -46,112
S$3509
  Bottom 0.152: -44.8,113 -44.4,112.6
S$3510
  Bottom 0.152: -44.4,112.6 -44.4,112
S$3511
  Bottom 0.152: -42.8,113 -42.8,112
S$3512
  Bottom 0.152: -40.8,113 -41.2,112.6
S$3513
  Bottom 0.152: -41.2,112.6 -41.2,112
S$3514
  Bottom 0.152: -38.8,113 -39.6,112.2
S$3515
  Bottom 0.152: -39.6,112.2 -39.6,112
S$3516
  Bottom 0.152: -36.8,113 -37,113
S$3517
  Bottom 0.152: -37,113 -38,112
S$3518
  Bottom 0.152: -34.8,113 -35.4,113
S$3519
  Bottom 0.152: -35.4,113 -36.4,112
S$3520
  Bottom 0.152: -32.8,113 -33.8,112
S$3521
  Bottom 0.152: -33.8,112 -34.8,112
S$3522
  Bottom 0.152: -51.8,109 -50.8,108
S$3523
  Bottom 0.152: -50.8,108 -50,108
S$3524
  Bottom 0.152: -49.8,109 -48.8,108
S$3525
  Bottom 0.152: -48.8,108 -48.4,108
S$3526
  Bottom 0.152: -47.8,109 -46.8,108
S$3527
  Bottom 0.152: -45.8,109 -45.2,108.4
S$3528
  Bottom 0.152: -45.2,108.4 -45.2,108
S$3529
  Bottom 0.152: -43.8,109 -43.6,108.8
S$3530
  Bottom 0.152: -43.6,108.8 -43.6,108
S$3531
  Bottom 0.152: -41.8,109 -42,108.8
S$3532
  Bottom 0.152: -42,108.8 -42,108
S$3533
  Bottom 0.152: -39.8,109 -40.4,108.4
S$3534
  Bottom 0.152: -40.4,108.4 -40.4,108
S$3535
  Bottom 0.152: -37.8,109 -38.8,108
S$3536
  Bottom 0.152: -35.8,109 -36.8,108
S$3537
  Bottom 0.152: -36.8,108 -37.2,108
S$3538
  Bottom 0.152: -33.8,109 -34.8,108
S$3539