# EAGLE board Na61-LTT_PlexiBody (EAGLE 9.6.2), part 4 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
S$3540 (continued)
  Bottom 0.152: -36.6,103 -35.6,104
S$3541
  Bottom 0.152: -35.6,104 -34,104
S$3542
  Bottom 0.152: -34.6,103 -33.8,103
S$3543
  Bottom 0.152: -33.8,103 -32.8,104
S$3544
  Bottom 0.152: -32.8,104 -32.4,104
S$3545
  Bottom 0.152: -32.6,103 -31.8,103
S$3546
  Bottom 0.152: -31.8,103 -30.8,104
S$3547
  Bottom 0.152: -30.6,103 -30.2,103
S$3548
  Bottom 0.152: -30.2,103 -29.2,104
S$3549
  Bottom 0.152: -28.6,103 -27.6,104
S$3550
  Bottom 0.152: -26.6,103 -26,103.6
S$3551
  Bottom 0.152: -26,103.6 -26,104
S$3552
  Bottom 0.152: -35.6,107 -35,107
S$3553
  Bottom 0.152: -35,107 -34,108
S$3554
  Bottom 0.152: -34,108 -33.2,108
S$3555
  Bottom 0.152: -33.6,107 -33,107
S$3556
  Bottom 0.152: -33,107 -32,108
S$3557
  Bottom 0.152: -32,108 -31.6,108
S$3558
  Bottom 0.152: -31.6,107 -31,107
S$3559
  Bottom 0.152: -31,107 -30,108
S$3560
  Bottom 0.152: -29.6,107 -29.4,107
S$3561
  Bottom 0.152: -29.4,107 -28.4,108
S$3562
  Bottom 0.152: -27.6,107 -26.8,107.8
S$3563
  Bottom 0.152: -26.8,107.8 -26.8,108
S$3564
  Bottom 0.152: 1.6,113 0.6,112
S$3565
  Bottom 0.152: 0.6,112 -0.4,112
S$3566
  Bottom 0.152: -0.4,113 -1,113
S$3567
  Bottom 0.152: -1,113 -2,112
S$3568
  Bottom 0.152: -2.4,113 -2.6,113
S$3569
  Bottom 0.152: -2.6,113 -3.6,112
S$3570
  Bottom 0.152: -4.4,113 -5.2,112.2
S$3571
  Bottom 0.152: -5.2,112.2 -5.2,112
S$3572
  Bottom 0.152: -6.4,113 -6.8,112.6
S$3573
  Bottom 0.152: -6.8,112.6 -6.8,112
S$3574
  Bottom 0.152: -8.4,113 -8.4,112
S$3575
  Bottom 0.152: -10.4,113 -10,112.6
S$3576
  Bottom 0.152: -10,112.6 -10,112
S$3577
  Bottom 0.152: -12.4,113 -11.6,112.2
S$3578
  Bottom 0.152: -11.6,112.2 -11.6,112
S$3579
  Bottom 0.152: -14.4,113 -14.2,113
S$3580
  Bottom 0.152: -14.2,113 -13.2,112
S$3581
  Bottom 0.152: -16.4,113 -15.8,113
S$3582
  Bottom 0.152: -15.8,113 -14.8,112
S$3583
  Bottom 0.152: -18.4,113 -17.4,112
S$3584
  Bottom 0.152: -17.4,112 -16.4,112
S$3585
  Bottom 0.152: 0.6,109 -0.4,108
S$3586
  Bottom 0.152: -0.4,108 -1.2,108
S$3587
  Bottom 0.152: -1.4,109 -2.4,108
S$3588
  Bottom 0.152: -2.4,108 -2.8,108
S$3589
  Bottom 0.152: -3.4,109 -4.4,108
S$3590
  Bottom 0.152: -5.4,109 -6,108.4
S$3591
  Bottom 0.152: -6,108.4 -6,108
S$3592
  Bottom 0.152: -7.4,109 -7.6,108.8
S$3593
  Bottom 0.152: -7.6,108.8 -7.6,108
S$3594
  Bottom 0.152: -9.4,109 -9.2,108.8
S$3595
  Bottom 0.152: -9.2,108.8 -9.2,108
S$3596
  Bottom 0.152: -11.4,109 -10.8,108.4
S$3597
  Bottom 0.152: -10.8,108.4 -10.8,108
S$3598
  Bottom 0.152: -13.4,109 -12.4,108
S$3599
  Bottom 0.152: -15.4,109 -14.4,108
S$3600
  Bottom 0.152: -14.4,108 -14,108
S$3601
  Bottom 0.152: -17.4,109 -16.4,108
S$3602
  Bottom 0.152: -16.4,108 -15.6,108
S$3603
  Bottom 0.152: -14.6,103 -15.6,104
S$3604
  Bottom 0.152: -15.6,104 -17.2,104
S$3605
  Bottom 0.152: -16.6,103 -17.4,103
S$3606
  Bottom 0.152: -17.4,103 -18.4,104
S$3607
  Bottom 0.152: -18.4,104 -18.8,104
S$3608
  Bottom 0.152: -18.6,103 -19.4,103
S$3609
  Bottom 0.152: -19.4,103 -20.4,104
S$3610
  Bottom 0.152: -20.6,103 -21,103
S$3611
  Bottom 0.152: -21,103 -22,104
S$3612
  Bottom 0.152: -22.6,103 -23.6,104
S$3613
  Bottom 0.152: -24.6,103 -25.2,103.6
S$3614
  Bottom 0.152: -25.2,103.6 -25.2,104
S$3615
  Bottom 0.152: -15.6,107 -16.2,107
S$3616
  Bottom 0.152: -16.2,107 -17.2,108
S$3617
  Bottom 0.152: -17.2,108 -18,108
S$3618
  Bottom 0.152: -17.6,107 -18.2,107
S$3619
  Bottom 0.152: -18.2,107 -19.2,108
S$3620
  Bottom 0.152: -19.2,108 -19.6,108
S$3621
  Bottom 0.152: -19.6,107 -20.2,107
S$3622
  Bottom 0.152: -20.2,107 -21.2,108
S$3623
  Bottom 0.152: -21.6,107 -21.8,107
S$3624
  Bottom 0.152: -21.8,107 -22.8,108
S$3625
  Bottom 0.152: -23.6,107 -24.4,107.8
S$3626
  Bottom 0.152: -24.4,107.8 -24.4,108
S$3627
  Bottom 0.152: 0.4,107 1,107
S$3628
  Bottom 0.152: 1,107 2,108
S$3629
  Bottom 0.152: 2.4,107 2.6,107
S$3630
  Bottom 0.152: 2.6,107 3.6,108
S$3631
  Bottom 0.152: 4.4,107 5.2,107.8
S$3632
  Bottom 0.152: 5.2,107.8 5.2,108
S$3633
  Bottom 0.152: 6.4,107 6.8,107.4
S$3634
  Bottom 0.152: 6.8,107.4 6.8,108
S$3635
  Bottom 0.152: 8.4,107 8.4,108
S$3636
  Bottom 0.152: -1.6,107 -0.6,107
S$3637
  Bottom 0.152: -0.6,107 0.4,108
S$3638
  Bottom 0.152: -0.6,103 0.4,104
S$3639
  Bottom 0.152: 0.4,104 1.2,104
S$3640
  Bottom 0.152: 1.4,103 1.8,103
S$3641
  Bottom 0.152: 1.8,103 2.8,104
S$3642
  Bottom 0.152: 3.4,103 4.4,104
S$3643
  Bottom 0.152: 5.4,103 6,103.6
S$3644
  Bottom 0.152: 6,103.6 6,104
S$3645
  Bottom 0.152: 7.4,103 7.6,103.2
S$3646
  Bottom 0.152: 7.6,103.2 7.6,104
S$3647
  Bottom 0.152: 9.4,103 9.2,103.2
S$3648
  Bottom 0.152: 9.2,103.2 9.2,104
S$3649
  Bottom 0.152: 11.4,103 10.8,103.6
S$3650
  Bottom 0.152: 10.8,103.6 10.8,104
S$3651
  Bottom 0.152: 13.4,103 12.4,104
S$3652
  Bottom 0.152: 15.4,103 15,103
S$3653
  Bottom 0.152: 15,103 14,104
S$3654
  Bottom 0.152: 17.4,103 16.6,103
S$3655
  Bottom 0.152: 16.6,103 15.6,104
S$3656
  Bottom 0.152: 10.4,107 10,107.4
S$3657
  Bottom 0.152: 10,107.4 10,108
S$3658
  Bottom 0.152: 12.4,107 11.6,107.8
S$3659
  Bottom 0.152: 11.6,107.8 11.6,108
S$3660
  Bottom 0.152: 14.4,107 14.2,107
S$3661
  Bottom 0.152: 14.2,107 13.2,108
S$3662
  Bottom 0.152: 16.4,107 15.8,107
S$3663
  Bottom 0.152: 15.8,107 14.8,108
S$3664
  Bottom 0.152: 18.4,105 17.4,104
S$3665
  Bottom 0.152: 17.4,104 16.4,104
S$3666
  Bottom 0.152: 16.6,109 17.2,109
S$3667
  Bottom 0.152: 17.2,109 18.2,108
S$3668
  Bottom 0.152: 18.2,108 18.8,108
S$3669
  Bottom 0.152: 18.6,109 19.6,108
S$3670
  Bottom 0.152: 19.6,108 20.4,108
S$3671
  Bottom 0.152: 20.6,109 21.6,108
S$3672
  Bottom 0.152: 21.6,108 22,108
S$3673
  Bottom 0.152: 22.6,109 23.6,108
S$3674
  Bottom 0.152: 24.6,109 25.2,108.4
S$3675
  Bottom 0.152: 25.2,108.4 25.2,108
S$3676
  Bottom 0.152: 15.6,113 16.6,112
S$3677
  Bottom 0.152: 16.6,112 18,112
S$3678
  Bottom 0.152: 17.6,113 18,113
S$3679
  Bottom 0.152: 18,113 19,112
S$3680
  Bottom 0.152: 19,112 19.6,112
S$3681
  Bottom 0.152: 19.6,113 20.2,113
S$3682
  Bottom 0.152: 20.2,113 21.2,112
S$3683
  Bottom 0.152: 21.6,113 21.8,113
S$3684
  Bottom 0.152: 21.8,113 22.8,112
S$3685
  Bottom 0.152: 23.6,113 24.4,112.2
S$3686
  Bottom 0.152: 24.4,112.2 24.4,112
S$3687
  Bottom 0.152: 17.2,108 16,108
S$3688
  Bottom 0.152: 16,108 15,109
S$3689
  Bottom 0.152: 15,109 14.6,109
S$3690
  Bottom 0.152: 50.8,107 50.2,107
S$3691
  Bottom 0.152: 50.2,107 49.2,108
S$3692
  Bottom 0.152: 48.8,107 48.6,107
S$3693
  Bottom 0.152: 48.6,107 47.6,108
S$3694
  Bottom 0.152: 46.8,107 46,107.8
S$3695
  Bottom 0.152: 46,107.8 46,108
S$3696
  Bottom 0.152: 44.8,107 44.4,107.4
S$3697
  Bottom 0.152: 44.4,107.4 44.4,108
S$3698
  Bottom 0.152: 42.8,107 42.8,108
S$3699
  Bottom 0.152: 52.8,107 51.8,107
S$3700
  Bottom 0.152: 51.8,107 50.8,108
S$3701
  Bottom 0.152: 51.8,103 50.8,104
S$3702
  Bottom 0.152: 50.8,104 50,104
S$3703
  Bottom 0.152: 49.8,103 49.4,103
S$3704
  Bottom 0.152: 49.4,103 48.4,104
S$3705
  Bottom 0.152: 47.8,103 46.8,104
S$3706
  Bottom 0.152: 45.8,103 45.2,103.6
S$3707
  Bottom 0.152: 45.2,103.6 45.2,104
S$3708
  Bottom 0.152: 43.8,103 43.6,103.2
S$3709
  Bottom 0.152: 43.6,103.2 43.6,104
S$3710
  Bottom 0.152: 41.8,103 42,103.2
S$3711
  Bottom 0.152: 42,103.2 42,104
S$3712
  Bottom 0.152: 39.8,103 40.4,103.6
S$3713
  Bottom 0.152: 40.4,103.6 40.4,104
S$3714
  Bottom 0.152: 37.8,103 38.8,104
S$3715
  Bottom 0.152: 35.8,103 36.2,103
S$3716
  Bottom 0.152: 36.2,103 37.2,104
S$3717
  Bottom 0.152: 33.8,103 34.6,103
S$3718
  Bottom 0.152: 34.6,103 35.6,104
S$3719
  Bottom 0.152: 40.8,107 41.2,107.4
S$3720
  Bottom 0.152: 41.2,107.4 41.2,108
S$3721
  Bottom 0.152: 38.8,107 39.6,107.8
S$3722
  Bottom 0.152: 39.6,107.8 39.6,108
S$3723
  Bottom 0.152: 36.8,107 37,107
S$3724
  Bottom 0.152: 37,107 38,108
S$3725
  Bottom 0.152: 34.8,107 35.4,107
S$3726
  Bottom 0.152: 35.4,107 36.4,108
S$3727
  Bottom 0.152: 32.8,105 33.8,104
S$3728
  Bottom 0.152: 33.8,104 34.8,104
S$3729
  Bottom 0.152: 34.6,109 34,109
S$3730
  Bottom 0.152: 34,109 33,108
S$3731
  Bottom 0.152: 33,108 32.4,108
S$3732
  Bottom 0.152: 32.6,109 31.6,108
S$3733
  Bottom 0.152: 31.6,108 30.8,108
S$3734
  Bottom 0.152: 30.6,109 29.6,108
S$3735
  Bottom 0.152: 29.6,108 29.2,108
S$3736
  Bottom 0.152: 28.6,109 27.6,108
S$3737
  Bottom 0.152: 26.6,109 26,108.4
S$3738
  Bottom 0.152: 26,108.4 26,108
S$3739
  Bottom 0.152: 35.6,113 34.6,112
S$3740
  Bottom 0.152: 34.6,112 33.2,112
S$3741
  Bottom 0.152: 33.6,113 33.2,113
S$3742
  Bottom 0.152: 33.2,113 32.2,112
S$3743
  Bottom 0.152: 32.2,112 31.6,112
S$3744
  Bottom 0.152: 31.6,113 31,113
S$3745
  Bottom 0.152: 31,113 30,112
S$3746
  Bottom 0.152: 29.6,113 29.4,113
S$3747
  Bottom 0.152: 29.4,113 28.4,112
S$3748
  Bottom 0.152: 27.6,113 26.8,112.2
S$3749
  Bottom 0.152: 26.8,112.2 26.8,112
S$3750
  Bottom 0.152: 34,108 35.2,108
S$3751
  Bottom 0.152: 35.2,108 36.2,109
S$3752
  Bottom 0.152: 36.2,109 36.6,109
S$3753  (2 unrouted)
  Top 0.813: 65,112.5 65,103.5
  Top 1.8: 66,109.5 64,109.5 | 66,112.5 65,112.5 64,112.5 | 66,106.5 64,106.5 | 66,103.5 65,103.5 64,103.5
S$3754
  Top 1.778: -104.08,104.83 -104.08,106.35
S$3755
  Top 1.778: -104.08,109.65 -104.08,111.17
S$3756
  Top 1.778: -99,104.83 -99,106.35
S$3757
  Top 1.778: -99,109.65 -99,111.17
S$3758
  Top 1.778: -93.92,104.83 -93.92,106.35
S$3759
  Top 1.778: -93.92,109.65 -93.92,111.17
S$3760
  Top 1.778: 93.92,104.83 93.92,106.35
S$3761
  Top 1.778: 93.92,109.65 93.92,111.17
S$3762
  Top 1.778: 99,104.83 99,106.35
S$3763
  Top 1.778: 99,109.65 99,111.17
S$3764
  Top 1.778: 104.08,104.83 104.08,106.35
S$3765
  Top 1.778: 104.08,109.65 104.08,111.17
S$3766  (via drill 0.2)
  other vias: -25.6,114.4
S$3767  (via drill 0.2)
  other vias: -8.6,101.6
S$3768  (via drill 0.2)
  other vias: 8.6,114.4
S$3769  (via drill 0.2)
  other vias: 25.6,101.6
S$3770  (via drill 0.2)
  other vias: 41.6,114.4
S$3771  (via drill 0.2)
  other vias: 52.8,114.4
S$3772  (via drill 0.2)
  other vias: -41.6,101.6
S$3773  (via drill 0.2)
  other vias: -52.8,101.6
S$3774
  Bottom 0.8: 9.4,120.9 9.4,119.1
S$3775
  Bottom 0.8: 11.4,120.9 11.4,119.1
S$3776
  Bottom 0.8: 8.4,123.1 8.4,124.9
S$3777
  Bottom 0.8: 10.4,123.1 10.4,124.9
S$3778
  Bottom 0.8: 5.4,120.9 5.4,119.1
S$3779
  Bottom 0.8: 7.4,120.9 7.4,119.1
S$3780
  Bottom 0.8: 6.4,123.1 6.4,124.9
S$3781
  Bottom 0.8: 4.4,123.1 4.4,124.9
S$3782
  Bottom 0.8: 3.4,120.9 3.4,119.1
S$3783
  Bottom 0.8: 1.4,120.9 1.4,119.1
S$3784
  Bottom 0.8: 2.4,123.1 2.4,124.9
S$3785
  Bottom 0.8: 0.4,123.1 0.4,124.9
S$3786
  Bottom 0.8: -0.6,120.9 -0.6,119.1
S$3787
  Bottom 0.8: -2.6,120.9 -2.6,119.1
S$3788
  Bottom 0.8: -1.6,123.1 -1.6,124.9
S$3789
  Bottom 0.8: 17.4,120.9 17.4,119.1
S$3790
  Bottom 0.8: 19.4,120.9 19.4,119.1
S$3791
  Bottom 0.8: 16.4,123.1 16.4,124.9
S$3792
  Bottom 0.8: 18.4,123.1 18.4,124.9
S$3793
  Bottom 0.8: 13.4,120.9 13.4,119.1
S$3794
  Bottom 0.8: 15.4,120.9 15.4,119.1
S$3795
  Bottom 0.8: 12.4,123.1 12.4,124.9
S$3796
  Bottom 0.8: 14.4,123.1 14.4,124.9
S$3797
  Bottom 0.8: -7.4,128.9 -7.4,127.1
S$3798
  Bottom 0.8: -5.4,128.9 -5.4,127.1
S$3799
  Bottom 0.8: -8.4,131.1 -8.4,132.9
S$3800
  Bottom 0.8: -6.4,131.1 -6.4,132.9
S$3801
  Bottom 0.8: -11.4,128.9 -11.4,127.1
S$3802
  Bottom 0.8: -9.4,128.9 -9.4,127.1
S$3803
  Bottom 0.8: -10.4,131.1 -10.4,132.9
S$3804
  Bottom 0.8: -12.4,131.1 -12.4,132.9
S$3805
  Bottom 0.8: -13.4,128.9 -13.4,127.1
S$3806
  Bottom 0.8: -15.4,128.9 -15.4,127.1
S$3807
  Bottom 0.8: -14.4,131.1 -14.4,132.9
S$3808
  Bottom 0.8: -16.4,131.1 -16.4,132.9
S$3809
  Bottom 0.8: -17.4,128.9 -17.4,127.1
S$3810
  Bottom 0.8: -19.4,128.9 -19.4,127.1
S$3811
  Bottom 0.8: -18.4,131.1 -18.4,132.9
S$3812
  Bottom 0.8: 0.6,128.9 0.6,127.1
S$3813
  Bottom 0.8: 2.6,128.9 2.6,127.1
S$3814
  Bottom 0.8: -0.4,131.1 -0.4,132.9
S$3815
  Bottom 0.8: 1.6,131.1 1.6,132.9
S$3816
  Bottom 0.8: -3.4,128.9 -3.4,127.1
S$3817
  Bottom 0.8: -1.4,128.9 -1.4,127.1
S$3818
  Bottom 0.8: -4.4,131.1 -4.4,132.9
S$3819
  Bottom 0.8: -2.4,131.1 -2.4,132.9
S$3820
  Bottom 0.8: -24.6,120.9 -24.6,119.1
S$3821
  Bottom 0.8: -22.6,120.9 -22.6,119.1
S$3822
  Bottom 0.8: -25.6,123.1 -25.6,124.9
S$3823
  Bottom 0.8: -23.6,123.1 -23.6,124.9
S$3824
  Bottom 0.8: -28.6,120.9 -28.6,119.1
S$3825
  Bottom 0.8: -26.6,120.9 -26.6,119.1
S$3826
  Bottom 0.8: -27.6,123.1 -27.6,124.9
S$3827
  Bottom 0.8: -29.6,123.1 -29.6,124.9
S$3828
  Bottom 0.8: -30.6,120.9 -30.6,119.1
S$3829
  Bottom 0.8: -32.6,120.9 -32.6,119.1
S$3830
  Bottom 0.8: -31.6,123.1 -31.6,124.9
S$3831
  Bottom 0.8: -33.6,123.1 -33.6,124.9
S$3832
  Bottom 0.8: -34.6,120.9 -34.6,119.1
S$3833
  Bottom 0.8: -36.6,120.9 -36.6,119.1
S$3834
  Bottom 0.8: -35.6,123.1 -35.6,124.9
S$3835
  Bottom 0.8: -16.6,120.9 -16.6,119.1
S$3836
  Bottom 0.8: -14.6,120.9 -14.6,119.1
S$3837
  Bottom 0.8: -17.6,123.1 -17.6,124.9
S$3838
  Bottom 0.8: -15.6,123.1 -15.6,124.9
S$3839
  Bottom 0.8: -20.6,120.9 -20.6,119.1
S$3840
  Bottom 0.8: -18.6,120.9 -18.6,119.1
S$3841
  Bottom 0.8: -21.6,123.1 -21.6,124.9
S$3842
  Bottom 0.8: -19.6,123.1 -19.6,124.9
S$3843
  Bottom 0.8: 26.6,128.9 26.6,127.1
S$3844
  Bottom 0.8: 28.6,128.9 28.6,127.1
S$3845
  Bottom 0.8: 25.6,131.1 25.6,132.9
S$3846
  Bottom 0.8: 27.6,131.1 27.6,132.9
S$3847
  Bottom 0.8: 22.6,128.9 22.6,127.1
S$3848
  Bottom 0.8: 24.6,128.9 24.6,127.1
S$3849
  Bottom 0.8: 23.6,131.1 23.6,132.9
S$3850
  Bottom 0.8: 21.6,131.1 21.6,132.9
S$3851
  Bottom 0.8: 20.6,128.9 20.6,127.1
S$3852
  Bottom 0.8: 18.6,128.9 18.6,127.1
S$3853
  Bottom 0.8: 19.6,131.1 19.6,132.9
S$3854
  Bottom 0.8: 17.6,131.1 17.6,132.9
S$3855
  Bottom 0.8: 16.6,128.9 16.6,127.1
S$3856
  Bottom 0.8: 14.6,128.9 14.6,127.1
S$3857
  Bottom 0.8: 15.6,131.1 15.6,132.9
S$3858
  Bottom 0.8: 34.6,128.9 34.6,127.1
S$3859
  Bottom 0.8: 36.6,128.9 36.6,127.1
S$3860
  Bottom 0.8: 33.6,131.1 33.6,132.9
S$3861
  Bottom 0.8: 35.6,131.1 35.6,132.9
S$3862
  Bottom 0.8: 30.6,128.9 30.6,127.1
S$3863
  Bottom 0.8: 32.6,128.9 32.6,127.1
S$3864
  Bottom 0.8: 29.6,131.1 29.6,132.9
S$3865
  Bottom 0.8: 31.6,131.1 31.6,132.9
S$3866
  Bottom 0.8: -41.8,128.9 -41.8,127.1
S$3867
  Bottom 0.8: -39.8,128.9 -39.8,127.1
S$3868
  Bottom 0.8: -42.8,131.1 -42.8,132.9
S$3869
  Bottom 0.8: -40.8,131.1 -40.8,132.9
S$3870
  Bottom 0.8: -45.8,128.9 -45.8,127.1
S$3871
  Bottom 0.8: -43.8,128.9 -43.8,127.1
S$3872
  Bottom 0.8: -44.8,131.1 -44.8,132.9
S$3873
  Bottom 0.8: -46.8,131.1 -46.8,132.9
S$3874
  Bottom 0.8: -47.8,128.9 -47.8,127.1
S$3875
  Bottom 0.8: -49.8,128.9 -49.8,127.1
S$3876
  Bottom 0.8: -48.8,131.1 -48.8,132.9
S$3877
  Bottom 0.8: -50.8,131.1 -50.8,132.9
S$3878
  Bottom 0.8: -51.8,128.9 -51.8,127.1
S$3879
  Bottom 0.8: -53.8,128.9 -53.8,127.1
S$3880
  Bottom 0.8: -52.8,131.1 -52.8,132.9
S$3881
  Bottom 0.8: -33.8,128.9 -33.8,127.1
S$3882
  Bottom 0.8: -31.8,128.9 -31.8,127.1
S$3883
  Bottom 0.8: -34.8,131.1 -34.8,132.9
S$3884
  Bottom 0.8: -32.8,131.1 -32.8,132.9
S$3885
  Bottom 0.8: -37.8,128.9 -37.8,127.1
S$3886
  Bottom 0.8: -35.8,128.9 -35.8,127.1
S$3887
  Bottom 0.8: -38.8,131.1 -38.8,132.9
S$3888
  Bottom 0.8: -36.8,131.1 -36.8,132.9
S$3889
  Bottom 0.8: 43.8,120.9 43.8,119.1
S$3890
  Bottom 0.8: 45.8,120.9 45.8,119.1
S$3891
  Bottom 0.8: 42.8,123.1 42.8,124.9
S$3892
  Bottom 0.8: 44.8,123.1 44.8,124.9
S$3893
  Bottom 0.8: 39.8,120.9 39.8,119.1
S$3894
  Bottom 0.8: 41.8,120.9 41.8,119.1
S$3895
  Bottom 0.8: 40.8,123.1 40.8,124.9
S$3896
  Bottom 0.8: 38.8,123.1 38.8,124.9
S$3897
  Bottom 0.8: 37.8,120.9 37.8,119.1
S$3898
  Bottom 0.8: 35.8,120.9 35.8,119.1
S$3899
  Bottom 0.8: 36.8,123.1 36.8,124.9
S$3900
  Bottom 0.8: 34.8,123.1 34.8,124.9
S$3901
  Bottom 0.8: 33.8,120.9 33.8,119.1
S$3902
  Bottom 0.8: 31.8,120.9 31.8,119.1
S$3903
  Bottom 0.8: 32.8,123.1 32.8,124.9
S$3904
  Bottom 0.8: 51.8,120.9 51.8,119.1
S$3905
  Bottom 0.8: 53.8,120.9 53.8,119.1
S$3906
  Bottom 0.8: 50.8,123.1 50.8,124.9
S$3907
  Bottom 0.8: 52.8,123.1 52.8,124.9
S$3908
  Bottom 0.8: 47.8,120.9 47.8,119.1
S$3909
  Bottom 0.8: 49.8,120.9 49.8,119.1
S$3910
  Bottom 0.8: 46.8,123.1 46.8,124.9
S$3911
  Bottom 0.8: 48.8,123.1 48.8,124.9
S$3912  (via drill 0.2)
  other vias: -50.8,130
S$3913  (via drill 0.2)
  other vias: -49.2,130
S$3914  (via drill 0.2)
  other vias: -47.6,130
S$3915  (via drill 0.2)
  other vias: -46,130
S$3916  (via drill 0.2)
  other vias: -44.4,130
S$3917  (via drill 0.2)
  other vias: -42.8,130
S$3918  (via drill 0.2)
  other vias: -41.2,130
S$3919  (via drill 0.2)
  other vias: -39.6,130
S$3920  (via drill 0.2)
  other vias: -38,130
S$3921  (via drill 0.2)
  other vias: -36.4,130
S$3922  (via drill 0.2)
  other vias: -34.8,130
S$3923  (via drill 0.2)
  other vias: -50,126
S$3924  (via drill 0.2)
  other vias: -48.4,126
S$3925  (via drill 0.2)
  other vias: -46.8,126
S$3926  (via drill 0.2)
  other vias: -45.2,126
S$3927  (via drill 0.2)
  other vias: -43.6,126
S$3928  (via drill 0.2)
  other vias: -42,126
S$3929  (via drill 0.2)
  other vias: -40.4,126
S$3930  (via drill 0.2)
  other vias: -38.8,126
S$3931  (via drill 0.2)
  other vias: -37.2,126
S$3932  (via drill 0.2)
  other vias: -35.6,126
S$3933  (via drill 0.2)
  other vias: -34,122
S$3934  (via drill 0.2)
  other vias: -32.4,122
S$3935  (via drill 0.2)
  other vias: -30.8,122
S$3936  (via drill 0.2)
  other vias: -29.2,122
S$3937  (via drill 0.2)
  other vias: -27.6,122
S$3938  (via drill 0.2)
  other vias: -33.2,126
S$3939  (via drill 0.2)
  other vias: -31.6,126
S$3940  (via drill 0.2)
  other vias: -30,126
S$3941  (via drill 0.2)
  other vias: -28.4,126
S$3942  (via drill 0.2)
  other vias: -26.8,126
S$3943  (via drill 0.2)
  other vias: -26,122
S$3944  (via drill 0.2)
  other vias: -0.4,130
S$3945  (via drill 0.2)
  other vias: -2,130
S$3946  (via drill 0.2)
  other vias: -3.6,130
S$3947  (via drill 0.2)
  other vias: -5.2,130
S$3948  (via drill 0.2)
  other vias: -6.8,130
S$3949  (via drill 0.2)
  other vias: -8.4,130
S$3950  (via drill 0.2)
  other vias: -10,130
S$3951  (via drill 0.2)
  other vias: -11.6,130
S$3952  (via drill 0.2)
  other vias: -13.2,130
S$3953  (via drill 0.2)
  other vias: -14.8,130
S$3954  (via drill 0.2)
  other vias: -16.4,130
S$3955  (via drill 0.2)
  other vias: -1.2,126
S$3956  (via drill 0.2)
  other vias: -2.8,126
S$3957  (via drill 0.2)
  other vias: -4.4,126
S$3958  (via drill 0.2)
  other vias: -6,126
S$3959  (via drill 0.2)
  other vias: -7.6,126
S$3960  (via drill 0.2)
  other vias: -9.2,126
S$3961  (via drill 0.2)
  other vias: -10.8,126
S$3962  (via drill 0.2)
  other vias: -12.4,126
S$3963  (via drill 0.2)
  other vias: -14,126
S$3964  (via drill 0.2)
  other vias: -15.6,126
S$3965  (via drill 0.2)
  other vias: -17.2,122
S$3966  (via drill 0.2)
  other vias: -18.8,122
S$3967  (via drill 0.2)
  other vias: -20.4,122
S$3968  (via drill 0.2)
  other vias: -22,122
S$3969  (via drill 0.2)
  other vias: -23.6,122
S$3970  (via drill 0.2)
  other vias: -18,126
S$3971  (via drill 0.2)
  other vias: -19.6,126
S$3972  (via drill 0.2)
  other vias: -21.2,126
S$3973  (via drill 0.2)
  other vias: -22.8,126
S$3974  (via drill 0.2)
  other vias: -24.4,126
S$3975  (via drill 0.2)
  other vias: -25.2,122
S$3976  (via drill 0.2)
  other vias: 0.4,126
S$3977  (via drill 0.2)
  other vias: 2,126
S$3978  (via drill 0.2)
  other vias: 3.6,126
S$3979  (via drill 0.2)
  other vias: 5.2,126
S$3980  (via drill 0.2)
  other vias: 6.8,126
S$3981  (via drill 0.2)
  other vias: 8.4,126
S$3982  (via drill 0.2)
  other vias: 10,126
S$3983  (via drill 0.2)
  other vias: 11.6,126
S$3984  (via drill 0.2)
  other vias: 13.2,126
S$3985  (via drill 0.2)
  other vias: 14.8,126
S$3986  (via drill 0.2)
  other vias: 16.4,122
S$3987  (via drill 0.2)
  other vias: 1.2,122
S$3988  (via drill 0.2)
  other vias: 2.8,122
S$3989  (via drill 0.2)
  other vias: 4.4,122
S$3990  (via drill 0.2)
  other vias: 6,122
S$3991  (via drill 0.2)
  other vias: 7.6,122
S$3992  (via drill 0.2)
  other vias: 9.2,122
S$3993  (via drill 0.2)
  other vias: 10.8,122
S$3994  (via drill 0.2)
  other vias: 12.4,122
S$3995  (via drill 0.2)
  other vias: 14,122
S$3996  (via drill 0.2)
  other vias: 15.6,122
S$3997  (via drill 0.2)
  other vias: 17.2,126
S$3998  (via drill 0.2)
  other vias: 18.8,126
S$3999  (via drill 0.2)
  other vias: 20.4,126
S$4000  (via drill 0.2)
  other vias: 18,130
S$4001  (via drill 0.2)
  other vias: 19.6,130
S$4002  (via drill 0.2)
  other vias: 21.2,130
S$4003  (via drill 0.2)
  other vias: 22,126
S$4004  (via drill 0.2)
  other vias: 22.8,130
S$4005  (via drill 0.2)
  other vias: 23.6,126
S$4006  (via drill 0.2)
  other vias: 24.4,130
S$4007  (via drill 0.2)
  other vias: 25.2,126
S$4008  (via drill 0.2)
  other vias: 50.8,126
S$4009  (via drill 0.2)
  other vias: 49.2,126
S$4010  (via drill 0.2)
  other vias: 47.6,126
S$4011  (via drill 0.2)
  other vias: 46,126
S$4012  (via drill 0.2)
  other vias: 44.4,126
S$4013  (via drill 0.2)
  other vias: 42.8,126
S$4014  (via drill 0.2)
  other vias: 41.2,126
S$4015  (via drill 0.2)
  other vias: 39.6,126
S$4016  (via drill 0.2)
  other vias: 38,126
S$4017  (via drill 0.2)
  other vias: 36.4,126
S$4018  (via drill 0.2)
  other vias: 34.8,122
S$4019  (via drill 0.2)
  other vias: 50,122
S$4020  (via drill 0.2)
  other vias: 48.4,122
S$4021  (via drill 0.2)
  other vias: 46.8,122
S$4022  (via drill 0.2)
  other vias: 45.2,122
S$4023  (via drill 0.2)
  other vias: 43.6,122
S$4024  (via drill 0.2)
  other vias: 42,122
S$4025  (via drill 0.2)
  other vias: 40.4,122
S$4026  (via drill 0.2)
  other vias: 38.8,122
S$4027  (via drill 0.2)
  other vias: 37.2,122
S$4028  (via drill 0.2)
  other vias: 35.6,122
S$4029  (via drill 0.2)
  other vias: 34,126
S$4030  (via drill 0.2)
  other vias: 32.4,126
S$4031  (via drill 0.2)
  other vias: 30.8,126
S$4032  (via drill 0.2)
  other vias: 33.2,130
S$4033  (via drill 0.2)
  other vias: 31.6,130
S$4034  (via drill 0.2)
  other vias: 30,130
S$4035  (via drill 0.2)
  other vias: 29.2,126
S$4036  (via drill 0.2)
  other vias: 28.4,130
S$4037  (via drill 0.2)
  other vias: 27.6,126
S$4038  (via drill 0.2)
  other vias: 26.8,130
S$4039  (via drill 0.2)
  other vias: 26,126
S$4040
  Bottom 0.152: -52.8,131 -51.8,130
S$4041
  Bottom 0.152: -51.8,130 -50.8,130
S$4042
  Bottom 0.152: -50.8,131 -50.2,131
S$4043
  Bottom 0.152: -50.2,131 -49.2,130
S$4044
  Bottom 0.152: -48.8,131 -48.6,131
S$4045
  Bottom 0.152: -48.6,131 -47.6,130
S$4046
  Bottom 0.152: -46.8,131 -46,130.2
S$4047
  Bottom 0.152: -46,130.2 -46,130
S$4048
  Bottom 0.152: -44.8,131 -44.4,130.6
S$4049
  Bottom 0.152: -44.4,130.6 -44.4,130
S$4050
  Bottom 0.152: -42.8,131 -42.8,130
S$4051
  Bottom 0.152: -40.8,131 -41.2,130.6
S$4052
  Bottom 0.152: -41.2,130.6 -41.2,130
S$4053
  Bottom 0.152: -38.8,131 -39.6,130.2
S$4054
  Bottom 0.152: -39.6,130.2 -39.6,130
S$4055
  Bottom 0.152: -36.8,131 -37,131
S$4056
  Bottom 0.152: -37,131 -38,130
S$4057
  Bottom 0.152: -34.8,131 -35.4,131
S$4058
  Bottom 0.152: -35.4,131 -36.4,130
S$4059
  Bottom 0.152: -32.8,131 -33.8,130
S$4060
  Bottom 0.152: -33.8,130 -34.8,130
S$4061
  Bottom 0.152: -51.8,127 -50.8,126
S$4062
  Bottom 0.152: -50.8,126 -50,126
S$4063
  Bottom 0.152: -49.8,127 -48.8,126
S$4064
  Bottom 0.152: -48.8,126 -48.4,126
S$4065
  Bottom 0.152: -47.8,127 -46.8,126
S$4066
  Bottom 0.152: -45.8,127 -45.2,126.4
S$4067
  Bottom 0.152: -45.2,126.4 -45.2,126
S$4068
  Bottom 0.152: -43.8,127 -43.6,126.8
S$4069
  Bottom 0.152: -43.6,126.8 -43.6,126
S$4070
  Bottom 0.152: -41.8,127 -42,126.8
S$4071
  Bottom 0.152: -42,126.8 -42,126
S$4072
  Bottom 0.152: -39.8,127 -40.4,126.4
S$4073
  Bottom 0.152: -40.4,126.4 -40.4,126
S$4074
  Bottom 0.152: -37.8,127 -38.8,126
S$4075
  Bottom 0.152: -35.8,127 -36.8,126
S$4076
  Bottom 0.152: -36.8,126 -37.2,126
S$4077
  Bottom 0.152: -33.8,127 -34.8,126
S$4078
  Bottom 0.152: -34.8,126 -35.6,126
S$4079
  Bottom 0.152: -36.6,121 -35.6,122
S$4080
  Bottom 0.152: -35.6,122 -34,122
S$4081
  Bottom 0.152: -34.6,121 -33.8,121
S$4082
  Bottom 0.152: -33.8,121 -32.8,122
S$4083
  Bottom 0.152: -32.8,122 -32.4,122
S$4084
  Bottom 0.152: -32.6,121 -31.8,121
S$4085
  Bottom 0.152: -31.8,121 -30.8,122
S$4086
  Bottom 0.152: -30.6,121 -30.2,121
S$4087
  Bottom 0.152: -30.2,121 -29.2,122
S$4088
  Bottom 0.152: -28.6,121 -27.6,122
S$4089
  Bottom 0.152: -26.6,121 -26,121.6
S$4090
  Bottom 0.152: -26,121.6 -26,122
S$4091
  Bottom 0.152: -35.6,125 -35,125
S$4092
  Bottom 0.152: -35,125 -34,126
S$4093
  Bottom 0.152: -34,126 -33.2,126
S$4094
  Bottom 0.152: -33.6,125 -33,125
S$4095
  Bottom 0.152: -33,125 -32,126
S$4096
  Bottom 0.152: -32,126 -31.6,126
S$4097
  Bottom 0.152: -31.6,125 -31,125
S$4098
  Bottom 0.152: -31,125 -30,126
S$4099
  Bottom 0.152: -29.6,125 -29.4,125
S$4100
  Bottom 0.152: -29.4,125 -28.4,126
S$4101
  Bottom 0.152: -27.6,125 -26.8,125.8
S$4102
  Bottom 0.152: -26.8,125.8 -26.8,126
S$4103
  Bottom 0.152: 1.6,131 0.6,130
S$4104
  Bottom 0.152: 0.6,130 -0.4,130
S$4105
  Bottom 0.152: -0.4,131 -1,131
S$4106
  Bottom 0.152: -1,131 -2,130
S$4107
  Bottom 0.152: -2.4,131 -2.6,131
S$4108
  Bottom 0.152: -2.6,131 -3.6,130
S$4109
  Bottom 0.152: -4.4,131 -5.2,130.2
S$4110
  Bottom 0.152: -5.2,130.2 -5.2,130
S$4111
  Bottom 0.152: -6.4,131 -6.8,130.6
S$4112
  Bottom 0.152: -6.8,130.6 -6.8,130
S$4113
  Bottom 0.152: -8.4,131 -8.4,130
S$4114
  Bottom 0.152: -10.4,131 -10,130.6
S$4115
  Bottom 0.152: -10,130.6 -10,130
S$4116
  Bottom 0.152: -12.4,131 -11.6,130.2
S$4117
  Bottom 0.152: -11.6,130.2 -11.6,130
S$4118
  Bottom 0.152: -14.4,131 -14.2,131
S$4119
  Bottom 0.152: -14.2,131 -13.2,130
S$4120
  Bottom 0.152: -16.4,131 -15.8,131
S$4121
  Bottom 0.152: -15.8,131 -14.8,130
S$4122
  Bottom 0.152: -18.4,131 -17.4,130
S$4123
  Bottom 0.152: -17.4,130 -16.4,130
S$4124
  Bottom 0.152: 0.6,127 -0.4,126
S$4125
  Bottom 0.152: -0.4,126 -1.2,126
S$4126
  Bottom 0.152: -1.4,127 -2.4,126
S$4127
  Bottom 0.152: -2.4,126 -2.8,126
S$4128
  Bottom 0.152: -3.4,127 -4.4,126
S$4129
  Bottom 0.152: -5.4,127 -6,126.4
S$4130
  Bottom 0.152: -6,126.4 -6,126
S$4131
  Bottom 0.152: -7.4,127 -7.6,126.8
S$4132
  Bottom 0.152: -7.6,126.8 -7.6,126
S$4133
  Bottom 0.152: -9.4,127 -9.2,126.8
S$4134
  Bottom 0.152: -9.2,126.8 -9.2,126
S$4135
  Bottom 0.152: -11.4,127 -10.8,126.4
S$4136
  Bottom 0.152: -10.8,126.4 -10.8,126
S$4137
  Bottom 0.152: -13.4,127 -12.4,126
S$4138
  Bottom 0.152: -15.4,127 -14.4,126
S$4139
  Bottom 0.152: -14.4,126 -14,126
S$4140
  Bottom 0.152: -17.4,127 -16.4,126
S$4141
  Bottom 0.152: -16.4,126 -15.6,126
S$4142
  Bottom 0.152: -14.6,121 -15.6,122
S$4143
  Bottom 0.152: -15.6,122 -17.2,122
S$4144
  Bottom 0.152: -16.6,121 -17.4,121
S$4145
  Bottom 0.152: -17.4,121 -18.4,122
S$4146
  Bottom 0.152: -18.4,122 -18.8,122
S$4147
  Bottom 0.152: -18.6,121 -19.4,121
S$4148
  Bottom 0.152: -19.4,121 -20.4,122
S$4149
  Bottom 0.152: -20.6,121 -21,121
S$4150
  Bottom 0.152: -21,121 -22,122
S$4151
  Bottom 0.152: -22.6,121 -23.6,122
S$4152
  Bottom 0.152: -24.6,121 -25.2,121.6
S$4153
  Bottom 0.152: -25.2,121.6 -25.2,122
S$4154
  Bottom 0.152: -15.6,125 -16.2,125
S$4155
  Bottom 0.152: -16.2,125 -17.2,126
S$4156
  Bottom 0.152: -17.2,126 -18,126
S$4157
  Bottom 0.152: -17.6,125 -18.2,125
S$4158
  Bottom 0.152: -18.2,125 -19.2,126
S$4159
  Bottom 0.152: -19.2,126 -19.6,126
S$4160
  Bottom 0.152: -19.6,125 -20.2,125
S$4161
  Bottom 0.152: -20.2,125 -21.2,126
S$4162
  Bottom 0.152: -21.6,125 -21.8,125
S$4163
  Bottom 0.152: -21.8,125 -22.8,126
S$4164
  Bottom 0.152: -23.6,125 -24.4,125.8
S$4165
  Bottom 0.152: -24.4,125.8 -24.4,126
S$4166
  Bottom 0.152: 0.4,125 1,125
S$4167
  Bottom 0.152: 1,125 2,126
S$4168
  Bottom 0.152: 2.4,125 2.6,125
S$4169
  Bottom 0.152: 2.6,125 3.6,126
S$4170
  Bottom 0.152: 4.4,125 5.2,125.8
S$4171
  Bottom 0.152: 5.2,125.8 5.2,126
S$4172
  Bottom 0.152: 6.4,125 6.8,125.4
S$4173
  Bottom 0.152: 6.8,125.4 6.8,126
S$4174
  Bottom 0.152: 8.4,125 8.4,126
S$4175
  Bottom 0.152: -1.6,125 -0.6,125
S$4176
  Bottom 0.152: -0.6,125 0.4,126
S$4177
  Bottom 0.152: -0.6,121 0.4,122
S$4178
  Bottom 0.152: 0.4,122 1.2,122
S$4179
  Bottom 0.152: 1.4,121 1.8,121
S$4180
  Bottom 0.152: 1.8,121 2.8,122
S$4181
  Bottom 0.152: 3.4,121 4.4,122
S$4182
  Bottom 0.152: 5.4,121 6,121.6
S$4183
  Bottom 0.152: 6,121.6 6,122
S$4184
  Bottom 0.152: 7.4,121 7.6,121.2
S$4185
  Bottom 0.152: 7.6,121.2 7.6,122
S$4186
  Bottom 0.152: 9.4,121 9.2,121.2
S$4187
  Bottom 0.152: 9.2,121.2 9.2,122
S$4188
  Bottom 0.152: 11.4,121 10.8,121.6
S$4189
  Bottom 0.152: 10.8,121.6 10.8,122
S$4190
  Bottom 0.152: 13.4,121 12.4,122
S$4191
  Bottom 0.152: 15.4,121 15,121
S$4192
  Bottom 0.152: 15,121 14,122
S$4193
  Bottom 0.152: 17.4,121 16.6,121
S$4194
  Bottom 0.152: 16.6,121 15.6,122
S$4195
  Bottom 0.152: 10.4,125 10,125.4
S$4196
  Bottom 0.152: 10,125.4 10,126
S$4197
  Bottom 0.152: 12.4,125 11.6,125.8
S$4198
  Bottom 0.152: 11.6,125.8 11.6,126
S$4199
  Bottom 0.152: 14.4,125 14.2,125
S$4200
  Bottom 0.152: 14.2,125 13.2,126
S$4201
  Bottom 0.152: 16.4,125 15.8,125
S$4202
  Bottom 0.152: 15.8,125 14.8,126
S$4203
  Bottom 0.152: 18.4,123 17.4,122
S$4204
  Bottom 0.152: 17.4,122 16.4,122
S$4205
  Bottom 0.152: 16.6,127 17.2,127
S$4206
  Bottom 0.152: 17.2,127 18.2,126
S$4207
  Bottom 0.152: 18.2,126 18.8,126
S$4208
  Bottom 0.152: 18.6,127 19.6,126
S$4209
  Bottom 0.152: 19.6,126 20.4,126
S$4210
  Bottom 0.152: 20.6,127 21.6,126
S$4211
  Bottom 0.152: 21.6,126 22,126
S$4212
  Bottom 0.152: 22.6,127 23.6,126
S$4213
  Bottom 0.152: 24.6,127 25.2,126.4
S$4214
  Bottom 0.152: 25.2,126.4 25.2,126
S$4215
  Bottom 0.152: 15.6,131 16.6,130
S$4216
  Bottom 0.152: 16.6,130 18,130
S$4217
  Bottom 0.152: 17.6,131 18,131
S$4218
  Bottom 0.152: 18,131 19,130
S$4219
  Bottom 0.152: 19,130 19.6,130
S$4220
  Bottom 0.152: 19.6,131 20.2,131
S$4221
  Bottom 0.152: 20.2,131 21.2,130
S$4222
  Bottom 0.152: 21.6,131 21.8,131
S$4223
  Bottom 0.152: 21.8,131 22.8,130
S$4224
  Bottom 0.152: 23.6,131 24.4,130.2
S$4225
  Bottom 0.152: 24.4,130.2 24.4,130
S$4226
  Bottom 0.152: 17.2,126 16,126
S$4227
  Bottom 0.152: 16,126 15,127
S$4228
  Bottom 0.152: 15,127 14.6,127
S$4229
  Bottom 0.152: 50.8,125 50.2,125
S$4230
  Bottom 0.152: 50.2,125 49.2,126
S$4231
  Bottom 0.152: 48.8,125 48.6,125
S$4232
  Bottom 0.152: 48.6,125 47.6,126
S$4233
  Bottom 0.152: 46.8,125 46,125.8
S$4234
  Bottom 0.152: 46,125.8 46,126
S$4235
  Bottom 0.152: 44.8,125 44.4,125.4
S$4236
  Bottom 0.152: 44.4,125.4 44.4,126
S$4237
  Bottom 0.152: 42.8,125 42.8,126
S$4238
  Bottom 0.152: 52.8,125 51.8,125
S$4239
  Bottom 0.152: 51.8,125 50.8,126
S$4240
  Bottom 0.152: 51.8,121 50.8,122
S$4241
  Bottom 0.152: 50.8,122 50,122
S$4242
  Bottom 0.152: 49.8,121 49.4,121
S$4243
  Bottom 0.152: 49.4,121 48.4,122
S$4244
  Bottom 0.152: 47.8,121 46.8,122
S$4245
  Bottom 0.152: 45.8,121 45.2,121.6
S$4246
  Bottom 0.152: 45.2,121.6 45.2,122
S$4247
  Bottom 0.152: 43.8,121 43.6,121.2
S$4248
  Bottom 0.152: 43.6,121.2 43.6,122
S$4249
  Bottom 0.152: 41.8,121 42,121.2
S$4250
  Bottom 0.152: 42,121.2 42,122
S$4251
  Bottom 0.152: 39.8,121 40.4,121.6
S$4252
  Bottom 0.152: 40.4,121.6 40.4,122
S$4253
  Bottom 0.152: 37.8,121 38.8,122
S$4254
  Bottom 0.152: 35.8,121 36.2,121
S$4255
  Bottom 0.152: 36.2,121 37.2,122
S$4256
  Bottom 0.152: 33.8,121 34.6,121
S$4257
  Bottom 0.152: 34.6,121 35.6,122
S$4258
  Bottom 0.152: 40.8,125 41.2,125.4
S$4259
  Bottom 0.152: 41.2,125.4 41.2,126
S$4260
  Bottom 0.152: 38.8,125 39.6,125.8
S$4261
  Bottom 0.152: 39.6,125.8 39.6,126
S$4262
  Bottom 0.152: 36.8,125 37,125
S$4263
  Bottom 0.152: 37,125 38,126
S$4264
  Bottom 0.152: 34.8,125 35.4,125
S$4265
  Bottom 0.152: 35.4,125 36.4,126
S$4266
  Bottom 0.152: 32.8,123 33.8,122
S$4267
  Bottom 0.152: 33.8,122 34.8,122
S$4268
  Bottom 0.152: 34.6,127 34,127
S$4269
  Bottom 0.152: 34,127 33,126
S$4270
  Bottom 0.152: 33,126 32.4,126
S$4271
  Bottom 0.152: 32.6,127 31.6,126
S$4272
  Bottom 0.152: 31.6,126 30.8,126
S$4273
  Bottom 0.152: 30.6,127 29.6,126
S$4274
  Bottom 0.152: 29.6,126 29.2,126
S$4275
  Bottom 0.152: 28.6,127 27.6,126
S$4276
  Bottom 0.152: 26.6,127 26,126.4
S$4277
  Bottom 0.152: 26,126.4 26,126
S$4278
  Bottom 0.152: 35.6,131 34.6,130
S$4279
  Bottom 0.152: 34.6,130 33.2,130
S$4280
  Bottom 0.152: 33.6,131 33.2,131
S$4281
  Bottom 0.152: 33.2,131 32.2,130
S$4282
  Bottom 0.152: 32.2,130 31.6,130
S$4283
  Bottom 0.152: 31.6,131 31,131
S$4284
  Bottom 0.152: 31,131 30,130
S$4285
  Bottom 0.152: 29.6,131 29.4,131
S$4286
  Bottom 0.152: 29.4,131 28.4,130
S$4287
  Bottom 0.152: 27.6,131 26.8,130.2
S$4288
  Bottom 0.152: 26.8,130.2 26.8,130
S$4289
  Bottom 0.152: 34,126 35.2,126
S$4290
  Bottom 0.152: 35.2,126 36.2,127
S$4291
  Bottom 0.152: 36.2,127 36.6,127
S$4292  (2 unrouted)
  Top 0.813: 65,130.5 65,121.5
  Top 1.8: 66,127.5 64,127.5 | 66,130.5 65,130.5 64,130.5 | 66,124.5 64,124.5 | 66,121.5 65,121.5 64,121.5
S$4293
  Top 1.778: -104.08,122.83 -104.08,124.35
S$4294
  Top 1.778: -104.08,127.65 -104.08,129.18
S$4295
  Top 1.778: -99,122.83 -99,124.35
S$4296
  Top 1.778: -99,127.65 -99,129.18
S$4297
  Top 1.778: -93.92,122.83 -93.92,124.35
S$4298
  Top 1.778: -93.92,127.65 -93.92,129.18
S$4299
  Top 1.778: 93.92,122.83 93.92,124.35
S$4300
  Top 1.778: 93.92,127.65 93.92,129.18
S$4301
  Top 1.778: 99,122.83 99,124.35
S$4302
  Top 1.778: 99,127.65 99,129.18
S$4303
  Top 1.778: 104.08,122.83 104.08,124.35
S$4304
  Top 1.778: 104.08,127.65 104.08,129.18
S$4305  (via drill 0.2)
  other vias: -25.6,132.4
S$4306  (via drill 0.2)
  other vias: -8.6,119.6
S$4307  (via drill 0.2)
  other vias: 8.6,132.4
S$4308  (via drill 0.2)
  other vias: 25.6,119.6
S$4309  (via drill 0.2)
  other vias: 41.6,132.4
S$4310  (via drill 0.2)
  other vias: 52.8,132.4
S$4311  (via drill 0.2)
  other vias: -41.6,119.6
S$4312  (via drill 0.2)
  other vias: -52.8,119.6
S$4313
  Bottom 0.8: 9.4,138.9 9.4,137.1
S$4314
  Bottom 0.8: 11.4,138.9 11.4,137.1
S$4315
  Bottom 0.8: 8.4,141.1 8.4,142.9
S$4316
  Bottom 0.8: 10.4,141.1 10.4,142.9
S$4317
  Bottom 0.8: 5.4,138.9 5.4,137.1
S$4318
  Bottom 0.8: 7.4,138.9 7.4,137.1
S$4319
  Bottom 0.8: 6.4,141.1 6.4,142.9
S$4320
  Bottom 0.8: 4.4,141.1 4.4,142.9
S$4321
  Bottom 0.8: 3.4,138.9 3.4,137.1
S$4322
  Bottom 0.8: 1.4,138.9 1.4,137.1
S$4323
  Bottom 0.8: 2.4,141.1 2.4,142.9
S$4324
  Bottom 0.8: 0.4,141.1 0.4,142.9
S$4325
  Bottom 0.8: -0.6,138.9 -0.6,137.1
S$4326
  Bottom 0.8: -2.6,138.9 -2.6,137.1
S$4327
  Bottom 0.8: -1.6,141.1 -1.6,142.9
S$4328
  Bottom 0.8: 17.4,138.9 17.4,137.1
S$4329
  Bottom 0.8: 19.4,138.9 19.4,137.1
S$4330
  Bottom 0.8: 16.4,141.1 16.4,142.9
S$4331
  Bottom 0.8: 18.4,141.1 18.4,142.9
S$4332
  Bottom 0.8: 13.4,138.9 13.4,137.1
S$4333
  Bottom 0.8: 15.4,138.9 15.4,137.1
S$4334
  Bottom 0.8: 12.4,141.1 12.4,142.9
S$4335
  Bottom 0.8: 14.4,141.1 14.4,142.9
S$4336
  Bottom 0.8: -7.4,146.9 -7.4,145.1
S$4337
  Bottom 0.8: -5.4,146.9 -5.4,145.1
S$4338
  Bottom 0.8: -8.4,149.1 -8.4,150.9
S$4339
  Bottom 0.8: -6.4,149.1 -6.4,150.9
S$4340
  Bottom 0.8: -11.4,146.9 -11.4,145.1
S$4341
  Bottom 0.8: -9.4,146.9 -9.4,145.1
S$4342
  Bottom 0.8: -10.4,149.1 -10.4,150.9
S$4343
  Bottom 0.8: -12.4,149.1 -12.4,150.9
S$4344
  Bottom 0.8: -13.4,146.9 -13.4,145.1
S$4345
  Bottom 0.8: -15.4,146.9 -15.4,145.1
S$4346
  Bottom 0.8: -14.4,149.1 -14.4,150.9
S$4347
  Bottom 0.8: -16.4,149.1 -16.4,150.9
S$4348
  Bottom 0.8: -17.4,146.9 -17.4,145.1
S$4349
  Bottom 0.8: -19.4,146.9 -19.4,145.1
S$4350
  Bottom 0.8: -18.4,149.1 -18.4,150.9
S$4351
  Bottom 0.8: 0.6,146.9 0.6,145.1
S$4352
  Bottom 0.8: 2.6,146.9 2.6,145.1
S$4353
  Bottom 0.8: -0.4,149.1 -0.4,150.9
S$4354
  Bottom 0.8: 1.6,149.1 1.6,150.9
S$4355
  Bottom 0.8: -3.4,146.9 -3.4,145.1
S$4356
  Bottom 0.8: -1.4,146.9 -1.4,145.1
S$4357
  Bottom 0.8: -4.4,149.1 -4.4,150.9
S$4358
  Bottom 0.8: -2.4,149.1 -2.4,150.9
S$4359
  Bottom 0.8: -24.6,138.9 -24.6,137.1
S$4360
  Bottom 0.8: -22.6,138.9 -22.6,137.1
S$4361
  Bottom 0.8: -25.6,141.1 -25.6,142.9
S$4362
  Bottom 0.8: -23.6,141.1 -23.6,142.9
S$4363
  Bottom 0.8: -28.6,138.9 -28.6,137.1
S$4364
  Bottom 0.8: -26.6,138.9 -26.6,137.1
S$4365
  Bottom 0.8: -27.6,141.1 -27.6,142.9
S$4366
  Bottom 0.8: -29.6,141.1 -29.6,142.9
S$4367
  Bottom 0.8: -30.6,138.9 -30.6,137.1
S$4368
  Bottom 0.8: -32.6,138.9 -32.6,137.1
S$4369
  Bottom 0.8: -31.6,141.1 -31.6,142.9
S$4370
  Bottom 0.8: -33.6,141.1 -33.6,142.9
S$4371
  Bottom 0.8: -34.6,138.9 -34.6,137.1
S$4372
  Bottom 0.8: -36.6,138.9 -36.6,137.1
S$4373
  Bottom 0.8: -35.6,141.1 -35.6,142.9
S$4374
  Bottom 0.8: -16.6,138.9 -16.6,137.1
S$4375
  Bottom 0.8: -14.6,138.9 -14.6,137.1
S$4376
  Bottom 0.8: -17.6,141.1 -17.6,142.9
S$4377
  Bottom 0.8: -15.6,141.1 -15.6,142.9
S$4378
  Bottom 0.8: -20.6,138.9 -20.6,137.1
S$4379
  Bottom 0.8: -18.6,138.9 -18.6,137.1
S$4380
  Bottom 0.8: -21.6,141.1 -21.6,142.9
S$4381
  Bottom 0.8: -19.6,141.1 -19.6,142.9
S$4382
  Bottom 0.8: 26.6,146.9 26.6,145.1
S$4383
  Bottom 0.8: 28.6,146.9 28.6,145.1
S$4384
  Bottom 0.8: 25.6,149.1 25.6,150.9
S$4385
  Bottom 0.8: 27.6,149.1 27.6,150.9
S$4386
  Bottom 0.8: 22.6,146.9 22.6,145.1
S$4387
  Bottom 0.8: 24.6,146.9 24.6,145.1
S$4388
  Bottom 0.8: 23.6,149.1 23.6,150.9
S$4389
  Bottom 0.8: 21.6,149.1 21.6,150.9
S$4390
  Bottom 0.8: 20.6,146.9 20.6,145.1
S$4391
  Bottom 0.8: 18.6,146.9 18.6,145.1
S$4392
  Bottom 0.8: 19.6,149.1 19.6,150.9
S$4393
  Bottom 0.8: 17.6,149.1 17.6,150.9
S$4394
  Bottom 0.8: 16.6,146.9 16.6,145.1
S$4395
  Bottom 0.8: 14.6,146.9 14.6,145.1
S$4396
  Bottom 0.8: 15.6,149.1 15.6,150.9
S$4397
  Bottom 0.8: 34.6,146.9 34.6,145.1
S$4398
  Bottom 0.8: 36.6,146.9 36.6,145.1
S$4399
  Bottom 0.8: 33.6,149.1 33.6,150.9
S$4400
  Bottom 0.8: 35.6,149.1 35.6,150.9
S$4401
  Bottom 0.8: 30.6,146.9 30.6,145.1
S$4402
  Bottom 0.8: 32.6,146.9 32.6,145.1
S$4403
  Bottom 0.8: 29.6,149.1 29.6,150.9
S$4404
  Bottom 0.8: 31.6,149.1 31.6,150.9
S$4405
  Bottom 0.8: -41.8,146.9 -41.8,145.1
S$4406
  Bottom 0.8: -39.8,146.9 -39.8,145.1
S$4407
  Bottom 0.8: -42.8,149.1 -42.8,150.9
S$4408
  Bottom 0.8: -40.8,149.1 -40.8,150.9
S$4409
  Bottom 0.8: -45.8,146.9 -45.8,145.1
S$4410
  Bottom 0.8: -43.8,146.9 -43.8,145.1
S$4411
  Bottom 0.8: -44.8,149.1 -44.8,150.9
S$4412
  Bottom 0.8: -46.8,149.1 -46.8,150.9
S$4413
  Bottom 0.8: -47.8,146.9 -47.8,145.1
S$4414
  Bottom 0.8: -49.8,146.9 -49.8,145.1
S$4415
  Bottom 0.8: -48.8,149.1 -48.8,150.9
S$4416
  Bottom 0.8: -50.8,149.1 -50.8,150.9
S$4417
  Bottom 0.8: -51.8,146.9 -51.8,145.1
S$4418
  Bottom 0.8: -53.8,146.9 -53.8,145.1
S$4419
  Bottom 0.8: -52.8,149.1 -52.8,150.9
S$4420
  Bottom 0.8: -33.8,146.9 -33.8,145.1
S$4421
  Bottom 0.8: -31.8,146.9 -31.8,145.1
S$4422
  Bottom 0.8: -34.8,149.1 -34.8,150.9
S$4423
  Bottom 0.8: -32.8,149.1 -32.8,150.9
S$4424
  Bottom 0.8: -37.8,146.9 -37.8,145.1
S$4425
  Bottom 0.8: -35.8,146.9 -35.8,145.1
S$4426
  Bottom 0.8: -38.8,149.1 -38.8,150.9
S$4427
  Bottom 0.8: -36.8,149.1 -36.8,150.9
S$4428
  Bottom 0.8: 43.8,138.9 43.8,137.1
S$4429
  Bottom 0.8: 45.8,138.9 45.8,137.1
S$4430
  Bottom 0.8: 42.8,141.1 42.8,142.9
S$4431
  Bottom 0.8: 44.8,141.1 44.8,142.9
S$4432
  Bottom 0.8: 39.8,138.9 39.8,137.1
S$4433
  Bottom 0.8: 41.8,138.9 41.8,137.1
S$4434
  Bottom 0.8: 40.8,141.1 40.8,142.9
S$4435
  Bottom 0.8: 38.8,141.1 38.8,142.9
S$4436
  Bottom 0.8: 37.8,138.9 37.8,137.1
S$4437
  Bottom 0.8: 35.8,138.9 35.8,137.1
S$4438
  Bottom 0.8: 36.8,141.1 36.8,142.9
S$4439
  Bottom 0.8: 34.8,141.1 34.8,142.9
S$4440
  Bottom 0.8: 33.8,138.9 33.8,137.1
S$4441
  Bottom 0.8: 31.8,138.9 31.8,137.1
S$4442
  Bottom 0.8: 32.8,141.1 32.8,142.9
S$4443
  Bottom 0.8: 51.8,138.9 51.8,137.1
S$4444
  Bottom 0.8: 53.8,138.9 53.8,137.1
S$4445
  Bottom 0.8: 50.8,141.1 50.8,142.9
S$4446
  Bottom 0.8: 52.8,141.1 52.8,142.9
S$4447
  Bottom 0.8: 47.8,138.9 47.8,137.1
S$4448
  Bottom 0.8: 49.8,138.9 49.8,137.1
S$4449
  Bottom 0.8: 46.8,141.1 46.8,142.9
S$4450
  Bottom 0.8: 48.8,141.1 48.8,142.9
S$4451  (via drill 0.2)
  other vias: -50.8,148
S$4452  (via drill 0.2)
  other vias: -49.2,148
S$4453  (via drill 0.2)
  other vias: -47.6,148
S$4454  (via drill 0.2)
  other vias: -46,148
S$4455  (via drill 0.2)
  other vias: -44.4,148
S$4456  (via drill 0.2)
  other vias: -42.8,148
S$4457  (via drill 0.2)
  other vias: -41.2,148
S$4458  (via drill 0.2)
  other vias: -39.6,148
S$4459  (via drill 0.2)
  other vias: -38,148
S$4460  (via drill 0.2)
  other vias: -36.4,148
S$4461  (via drill 0.2)
  other vias: -34.8,148
S$4462  (via drill 0.2)
  other vias: -50,144
S$4463  (via drill 0.2)
  other vias: -48.4,144
S$4464  (via drill 0.2)
  other vias: -46.8,144
S$4465  (via drill 0.2)
  other vias: -45.2,144
S$4466  (via drill 0.2)
  other vias: -43.6,144
S$4467  (via drill 0.2)
  other vias: -42,144
S$4468  (via drill 0.2)
  other vias: -40.4,144
S$4469  (via drill 0.2)
  other vias: -38.8,144
S$4470  (via drill 0.2)
  other vias: -37.2,144
S$4471  (via drill 0.2)
  other vias: -35.6,144
S$4472  (via drill 0.2)
  other vias: -34,140
S$4473  (via drill 0.2)
  other vias: -32.4,140
S$4474  (via drill 0.2)
  other vias: -30.8,140
S$4475  (via drill 0.2)
  other vias: -29.2,140
S$4476  (via drill 0.2)
  other vias: -27.6,140
S$4477  (via drill 0.2)
  other vias: -33.2,144
S$4478  (via drill 0.2)
  other vias: -31.6,144
S$4479  (via drill 0.2)
  other vias: -30,144
S$4480  (via drill 0.2)
  other vias: -28.4,144
S$4481  (via drill 0.2)
  other vias: -26.8,144
S$4482  (via drill 0.2)
  other vias: -26,140
S$4483  (via drill 0.2)
  other vias: -0.4,148
S$4484  (via drill 0.2)
  other vias: -2,148
S$4485  (via drill 0.2)
  other vias: -3.6,148
S$4486  (via drill 0.2)
  other vias: -5.2,148
S$4487  (via drill 0.2)
  other vias: -6.8,148
S$4488  (via drill 0.2)
  other vias: -8.4,148
S$4489  (via drill 0.2)
  other vias: -10,148
S$4490  (via drill 0.2)
  other vias: -11.6,148
S$4491  (via drill 0.2)
  other vias: -13.2,148
S$4492  (via drill 0.2)
  other vias: -14.8,148
S$4493  (via drill 0.2)
  other vias: -16.4,148
S$4494  (via drill 0.2)
  other vias: -1.2,144
S$4495  (via drill 0.2)
  other vias: -2.8,144
S$4496  (via drill 0.2)
  other vias: -4.4,144
S$4497  (via drill 0.2)
  other vias: -6,144
S$4498  (via drill 0.2)
  other vias: -7.6,144
S$4499  (via drill 0.2)
  other vias: -9.2,144
S$4500  (via drill 0.2)
  other vias: -10.8,144
S$4501  (via drill 0.2)
  other vias: -12.4,144
S$4502  (via drill 0.2)
  other vias: -14,144
S$4503  (via drill 0.2)
  other vias: -15.6,144
S$4504  (via drill 0.2)
  other vias: -17.2,140
S$4505  (via drill 0.2)
  other vias: -18.8,140
S$4506  (via drill 0.2)
  other vias: -20.4,140
S$4507  (via drill 0.2)
  other vias: -22,140
S$4508  (via drill 0.2)
  other vias: -23.6,140
S$4509  (via drill 0.2)
  other vias: -18,144
S$4510  (via drill 0.2)
  other vias: -19.6,144
S$4511  (via drill 0.2)
  other vias: -21.2,144
S$4512  (via drill 0.2)
  other vias: -22.8,144
S$4513  (via drill 0.2)
  other vias: -24.4,144
S$4514  (via drill 0.2)
  other vias: -25.2,140
S$4515  (via drill 0.2)
  other vias: 0.4,144
S$4516  (via drill 0.2)
  other vias: 2,144
S$4517  (via drill 0.2)
  other vias: 3.6,144
S$4518  (via drill 0.2)
  other vias: 5.2,144
S$4519  (via drill 0.2)
  other vias: 6.8,144
S$4520  (via drill 0.2)
  other vias: 8.4,144
S$4521  (via drill 0.2)
  other vias: 10,144
S$4522  (via drill 0.2)
  other vias: 11.6,144
S$4523  (via drill 0.2)
  other vias: 13.2,144
S$4524  (via drill 0.2)
  other vias: 14.8,144
S$4525  (via drill 0.2)
  other vias: 16.4,140
S$4526  (via drill 0.2)
  other vias: 1.2,140
S$4527  (via drill 0.2)
  other vias: 2.8,140
S$4528  (via drill 0.2)
  other vias: 4.4,140
S$4529  (via drill 0.2)
  other vias: 6,140
S$4530  (via drill 0.2)
  other vias: 7.6,140
S$4531  (via drill 0.2)
  other vias: 9.2,140
S$4532  (via drill 0.2)
  other vias: 10.8,140
S$4533  (via drill 0.2)
  other vias: 12.4,140
S$4534  (via drill 0.2)
  other vias: 14,140
S$4535  (via drill 0.2)
  other vias: 15.6,140
S$4536  (via drill 0.2)
  other vias: 17.2,144
S$4537  (via drill 0.2)
  other vias: 18.8,144
S$4538  (via drill 0.2)
  other vias: 20.4,144
S$4539  (via drill 0.2)
  other vias: 18,148
S$4540  (via drill 0.2)
  other vias: 19.6,148
S$4541  (via drill 0.2)
  other vias: 21.2,148
S$4542  (via drill 0.2)
  other vias: 22,144
S$4543  (via drill 0.2)
  other vias: 22.8,148
S$4544  (via drill 0.2)
  other vias: 23.6,144
S$4545  (via drill 0.2)
  other vias: 24.4,148
S$4546  (via drill 0.2)
  other vias: 25.2,144
S$4547  (via drill 0.2)
  other vias: 50.8,144
S$4548  (via drill 0.2)
  other vias: 49.2,144
S$4549  (via drill 0.2)
  other vias: 47.6,144
S$4550  (via drill 0.2)
  other vias: 46,144
S$4551  (via drill 0.2)
  other vias: 44.4,144
S$4552  (via drill 0.2)
  other vias: 42.8,144
S$4553  (via drill 0.2)
  other vias: 41.2,144
S$4554  (via drill 0.2)
  other vias: 39.6,144
S$4555  (via drill 0.2)
  other vias: 38,144
S$4556  (via drill 0.2)
  other vias: 36.4,144
S$4557  (via drill 0.2)
  other vias: 34.8,140
S$4558  (via drill 0.2)
  other vias: 50,140
S$4559  (via drill 0.2)
  other vias: 48.4,140
S$4560  (via drill 0.2)
  other vias: 46.8,140
S$4561  (via drill 0.2)
  other vias: 45.2,140
S$4562  (via drill 0.2)
  other vias: 43.6,140
S$4563  (via drill 0.2)
  other vias: 42,140
S$4564  (via drill 0.2)
  other vias: 40.4,140
S$4565  (via drill 0.2)
  other vias: 38.8,140
S$4566  (via drill 0.2)
  other vias: 37.2,140
S$4567  (via drill 0.2)
  other vias: 35.6,140
S$4568  (via drill 0.2)
  other vias: 34,144
S$4569  (via drill 0.2)
  other vias: 32.4,144
S$4570  (via drill 0.2)
  other vias: 30.8,144
S$4571  (via drill 0.2)
  other vias: 33.2,148
S$4572  (via drill 0.2)
  other vias: 31.6,148
S$4573  (via drill 0.2)
  other vias: 30,148
S$4574  (via drill 0.2)
  other vias: 29.2,144
S$4575  (via drill 0.2)
  other vias: 28.4,148
S$4576  (via drill 0.2)
  other vias: 27.6,144
S$4577  (via drill 0.2)
  other vias: 26.8,148
S$4578  (via drill 0.2)
  other vias: 26,144
S$4579
  Bottom 0.152: -52.8,149 -51.8,148
S$4580
  Bottom 0.152: -51.8,148 -50.8,148
S$4581
  Bottom 0.152: -50.8,149 -50.2,149
S$4582
  Bottom 0.152: -50.2,149 -49.2,148
S$4583
  Bottom 0.152: -48.8,149 -48.6,149
S$4584
  Bottom 0.152: -48.6,149 -47.6,148
S$4585
  Bottom 0.152: -46.8,149 -46,148.2
S$4586
  Bottom 0.152: -46,148.2 -46,148
S$4587
  Bottom 0.152: -44.8,149 -44.4,148.6
S$4588
  Bottom 0.152: -44.4,148.6 -44.4,148
S$4589
  Bottom 0.152: -42.8,149 -42.8,148
S$4590
  Bottom 0.152: -40.8,149 -41.2,148.6
S$4591
  Bottom 0.152: -41.2,148.6 -41.2,148
S$4592
  Bottom 0.152: -38.8,149 -39.6,148.2
S$4593
  Bottom 0.152: -39.6,148.2 -39.6,148
S$4594
  Bottom 0.152: -36.8,149 -37,149
S$4595
  Bottom 0.152: -37,149 -38,148
S$4596
  Bottom 0.152: -34.8,149 -35.4,149
S$4597
  Bottom 0.152: -35.4,149 -36.4,148
S$4598
  Bottom 0.152: -32.8,149 -33.8,148
S$4599
  Bottom 0.152: -33.8,148 -34.8,148
S$4600
  Bottom 0.152: -51.8,145 -50.8,144
S$4601
  Bottom 0.152: -50.8,144 -50,144
S$4602
  Bottom 0.152: -49.8,145 -48.8,144
S$4603
  Bottom 0.152: -48.8,144 -48.4,144
S$4604
  Bottom 0.152: -47.8,145 -46.8,144
S$4605
  Bottom 0.152: -45.8,145 -45.2,144.4
S$4606
  Bottom 0.152: -45.2,144.4 -45.2,144
S$4607
  Bottom 0.152: -43.8,145 -43.6,144.8
S$4608
  Bottom 0.152: -43.6,144.8 -43.6,144
S$4609
  Bottom 0.152: -41.8,145 -42,144.8
S$4610
  Bottom 0.152: -42,144.8 -42,144
S$4611
  Bottom 0.152: -39.8,145 -40.4,144.4
S$4612
  Bottom 0.152: -40.4,144.4 -40.4,144
S$4613
  Bottom 0.152: -37.8,145 -38.8,144
S$4614
  Bottom 0.152: -35.8,145 -36.8,144
S$4615
  Bottom 0.152: -36.8,144 -37.2,144
S$4616
  Bottom 0.152: -33.8,145 -34.8,144
S$4617
  Bottom 0.152: -34.8,144 -35.6,144
S$4618
  Bottom 0.152: -36.6,139 -35.6,140
S$4619
  Bottom 0.152: -35.6,140 -34,140
S$4620
  Bottom 0.152: -34.6,139 -33.8,139
S$4621
  Bottom 0.152: -33.8,139 -32.8,140
S$4622
  Bottom 0.152: -32.8,140 -32.4,140
S$4623
  Bottom 0.152: -32.6,139 -31.8,139
S$4624
  Bottom 0.152: -31.8,139 -30.8,140
S$4625
  Bottom 0.152: -30.6,139 -30.2,139
S$4626
  Bottom 0.152: -30.2,139 -29.2,140
S$4627
  Bottom 0.152: -28.6,139 -27.6,140
S$4628
  Bottom 0.152: -26.6,139 -26,139.6
S$4629
  Bottom 0.152: -26,139.6 -26,140
S$4630
  Bottom 0.152: -35.6,143 -35,143
S$4631
  Bottom 0.152: -35,143 -34,144
S$4632
  Bottom 0.152: -34,144 -33.2,144
S$4633
  Bottom 0.152: -33.6,143 -33,143
S$4634
  Bottom 0.152: -33,143 -32,144
S$4635
  Bottom 0.152: -32,144 -31.6,144
S$4636
  Bottom 0.152: -31.6,143 -31,143
S$4637
  Bottom 0.152: -31,143 -30,144
S$4638
  Bottom 0.152: -29.6,143 -29.4,143
S$4639
  Bottom 0.152: -29.4,143 -28.4,144
S$4640
  Bottom 0.152: -27.6,143 -26.8,143.8
S$4641
  Bottom 0.152: -26.8,143.8 -26.8,144
S$4642
  Bottom 0.152: 1.6,149 0.6,148
S$4643
  Bottom 0.152: 0.6,148 -0.4,148
S$4644
  Bottom 0.152: -0.4,149 -1,149
S$4645
  Bottom 0.152: -1,149 -2,148
S$4646
  Bottom 0.152: -2.4,149 -2.6,149
S$4647
  Bottom 0.152: -2.6,149 -3.6,148
S$4648
  Bottom 0.152: -4.4,149 -5.2,148.2
S$4649
  Bottom 0.152: -5.2,148.2 -5.2,148
S$4650
  Bottom 0.152: -6.4,149 -6.8,148.6
S$4651
  Bottom 0.152: -6.8,148.6 -6.8,148
S$4652
  Bottom 0.152: -8.4,149 -8.4,148
S$4653
  Bottom 0.152: -10.4,149 -10,148.6
S$4654
  Bottom 0.152: -10,148.6 -10,148
S$4655
  Bottom 0.152: -12.4,149 -11.6,148.2
S$4656
  Bottom 0.152: -11.6,148.2 -11.6,148
S$4657
  Bottom 0.152: -14.4,149 -14.2,149
S$4658
  Bottom 0.152: -14.2,149 -13.2,148
S$4659
  Bottom 0.152: -16.4,149 -15.8,149
S$4660
  Bottom 0.152: -15.8,149 -14.8,148
S$4661
  Bottom 0.152: -18.4,149 -17.4,148
S$4662
  Bottom 0.152: -17.4,148 -16.4,148
S$4663
  Bottom 0.152: 0.6,145 -0.4,144
S$4664
  Bottom 0.152: -0.4,144 -1.2,144
S$4665
  Bottom 0.152: -1.4,145 -2.4,144
S$4666
  Bottom 0.152: -2.4,144 -2.8,144
S$4667
  Bottom 0.152: -3.4,145 -4.4,144
S$4668
  Bottom 0.152: -5.4,145 -6,144.4
S$4669
  Bottom 0.152: -6,144.4 -6,144
S$4670
  Bottom 0.152: -7.4,145 -7.6,144.8
S$4671
  Bottom 0.152: -7.6,144.8 -7.6,144
S$4672
  Bottom 0.152: -9.4,145 -9.2,144.8
S$4673
  Bottom 0.152: -9.2,144.8 -9.2,144
S$4674
  Bottom 0.152: -11.4,145 -10.8,144.4
S$4675
  Bottom 0.152: -10.8,144.4 -10.8,144
S$4676